v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {TR-1um manual-routing view: maximally compacted rows, M1-horizontal / M2-vertical intent} 300 120 0 0 0.3 0.3 {}
T {Topology preserved; same-layer wire spacing >=10; no lab_pin remote connections} 300 160 0 0 0.2 0.2 {}
T {ROW 0} 220 270 0 0 0.14 0.14 {}
T {ROW 1} 220 580 0 0 0.14 0.14 {}
T {ROW 2} 220 870 0 0 0.14 0.14 {}
T {ROW 3} 220 1130 0 0 0.14 0.14 {}
T {ROW 4} 220 1430 0 0 0.14 0.14 {}
T {ROW 5} 220 1710 0 0 0.14 0.14 {}
T {ROW 6} 220 2010 0 0 0.14 0.14 {}
T {ROW 7} 220 2310 0 0 0.14 0.14 {}
T {ROW 8} 220 2640 0 0 0.14 0.14 {}
N 520 300 520 320 {lab=VDD}
N 520 400 520 420 {lab=VSS}
N 970 300 970 320 {lab=VDD}
N 970 400 970 420 {lab=VSS}
N 3210 300 3210 320 {lab=VDD}
N 3210 400 3210 420 {lab=VSS}
N 3640 300 3640 320 {lab=VDD}
N 3640 400 3640 420 {lab=VSS}
N 4100 300 4100 320 {lab=VDD}
N 4100 400 4100 420 {lab=VSS}
N 420 300 520 300 {lab=VDD}
N 520 300 970 300 {lab=VDD}
N 970 300 1390 300 {lab=VDD}
N 1390 300 1830 300 {lab=VDD}
N 1830 300 2280 300 {lab=VDD}
N 2280 300 2770 300 {lab=VDD}
N 2770 300 3210 300 {lab=VDD}
N 3210 300 3640 300 {lab=VDD}
N 3640 300 4100 300 {lab=VDD}
N 4100 300 4570 300 {lab=VDD}
N 4570 300 5040 300 {lab=VDD}
N 5040 300 5500 300 {lab=VDD}
N 5500 300 5940 300 {lab=VDD}
N 5940 300 6400 300 {lab=VDD}
N 520 420 970 420 {lab=VSS}
N 970 420 1390 420 {lab=VSS}
N 1390 420 1830 420 {lab=VSS}
N 1830 420 2280 420 {lab=VSS}
N 2280 420 2770 420 {lab=VSS}
N 2770 420 3210 420 {lab=VSS}
N 3210 420 3640 420 {lab=VSS}
N 3640 420 4100 420 {lab=VSS}
N 4100 420 4570 420 {lab=VSS}
N 4570 420 5040 420 {lab=VSS}
N 5040 420 5500 420 {lab=VSS}
N 5500 420 5940 420 {lab=VSS}
N 5940 420 6400 420 {lab=VSS}
N 6400 420 6540 420 {lab=VSS}
N 780 730 780 740 {lab=VSS}
N 1170 730 1170 740 {lab=VSS}
N 1630 730 1630 740 {lab=VSS}
N 2090 730 2090 740 {lab=VSS}
N 2570 730 2570 740 {lab=VSS}
N 2970 730 2970 740 {lab=VSS}
N 3450 730 3450 740 {lab=VSS}
N 3900 730 3900 740 {lab=VSS}
N 4360 730 4360 740 {lab=VSS}
N 4780 730 4780 740 {lab=VSS}
N 5300 730 5300 740 {lab=VSS}
N 5770 730 5770 740 {lab=VSS}
N 6210 730 6210 740 {lab=VSS}
N 420 610 780 610 {lab=VDD}
N 780 610 1170 610 {lab=VDD}
N 1170 610 1630 610 {lab=VDD}
N 1630 610 2090 610 {lab=VDD}
N 2090 610 2570 610 {lab=VDD}
N 2570 610 2970 610 {lab=VDD}
N 2970 610 3450 610 {lab=VDD}
N 3450 610 3900 610 {lab=VDD}
N 3900 610 4360 610 {lab=VDD}
N 4360 610 4780 610 {lab=VDD}
N 4780 610 5300 610 {lab=VDD}
N 5300 610 5770 610 {lab=VDD}
N 5770 610 6210 610 {lab=VDD}
N 780 740 1170 740 {lab=VSS}
N 1170 740 1630 740 {lab=VSS}
N 1630 740 2090 740 {lab=VSS}
N 2090 740 2570 740 {lab=VSS}
N 2570 740 2970 740 {lab=VSS}
N 2970 740 3450 740 {lab=VSS}
N 3450 740 3900 740 {lab=VSS}
N 3900 740 4360 740 {lab=VSS}
N 4360 740 4780 740 {lab=VSS}
N 4780 740 5300 740 {lab=VSS}
N 5300 740 5770 740 {lab=VSS}
N 5770 740 6210 740 {lab=VSS}
N 6210 740 6540 740 {lab=VSS}
N 520 900 520 920 {lab=VDD}
N 520 1000 520 1030 {lab=VSS}
N 980 900 980 920 {lab=VDD}
N 980 1000 980 1030 {lab=VSS}
N 1400 900 1400 920 {lab=VDD}
N 1400 1000 1400 1030 {lab=VSS}
N 1770 1020 1770 1030 {lab=VSS}
N 2280 1020 2280 1030 {lab=VSS}
N 2770 1020 2770 1030 {lab=VSS}
N 3210 1020 3210 1030 {lab=VSS}
N 3640 1020 3640 1030 {lab=VSS}
N 4040 1020 4040 1030 {lab=VSS}
N 4570 1020 4570 1030 {lab=VSS}
N 5040 1020 5040 1030 {lab=VSS}
N 5500 1020 5500 1030 {lab=VSS}
N 5940 1020 5940 1030 {lab=VSS}
N 6400 900 6400 920 {lab=VDD}
N 6400 1000 6400 1030 {lab=VSS}
N 420 900 520 900 {lab=VDD}
N 520 900 980 900 {lab=VDD}
N 980 900 1400 900 {lab=VDD}
N 1400 900 1770 900 {lab=VDD}
N 1770 900 2280 900 {lab=VDD}
N 2280 900 2770 900 {lab=VDD}
N 2770 900 3210 900 {lab=VDD}
N 3210 900 3640 900 {lab=VDD}
N 3640 900 4040 900 {lab=VDD}
N 4040 900 4570 900 {lab=VDD}
N 4570 900 5040 900 {lab=VDD}
N 5040 900 5500 900 {lab=VDD}
N 5500 900 5940 900 {lab=VDD}
N 5940 900 6400 900 {lab=VDD}
N 520 1030 980 1030 {lab=VSS}
N 980 1030 1400 1030 {lab=VSS}
N 1400 1030 1770 1030 {lab=VSS}
N 1770 1030 2280 1030 {lab=VSS}
N 2280 1030 2770 1030 {lab=VSS}
N 2770 1030 3210 1030 {lab=VSS}
N 3210 1030 3640 1030 {lab=VSS}
N 3640 1030 4040 1030 {lab=VSS}
N 4040 1030 4570 1030 {lab=VSS}
N 4570 1030 5040 1030 {lab=VSS}
N 5040 1030 5500 1030 {lab=VSS}
N 5500 1030 5940 1030 {lab=VSS}
N 5940 1030 6400 1030 {lab=VSS}
N 6400 1030 6540 1030 {lab=VSS}
N 720 1280 720 1290 {lab=VSS}
N 1170 1280 1170 1290 {lab=VSS}
N 1570 1280 1570 1290 {lab=VSS}
N 2100 1160 2100 1180 {lab=VDD}
N 2100 1260 2100 1290 {lab=VSS}
N 2570 1280 2570 1290 {lab=VSS}
N 3030 1280 3030 1290 {lab=VSS}
N 3450 1280 3450 1290 {lab=VSS}
N 3910 1160 3910 1180 {lab=VDD}
N 3910 1260 3910 1290 {lab=VSS}
N 4370 1160 4370 1180 {lab=VDD}
N 4370 1260 4370 1290 {lab=VSS}
N 4780 1280 4780 1290 {lab=VSS}
N 5310 1160 5310 1180 {lab=VDD}
N 5310 1260 5310 1290 {lab=VSS}
N 5710 1280 5710 1290 {lab=VSS}
N 6220 1160 6220 1180 {lab=VDD}
N 6220 1260 6220 1290 {lab=VSS}
N 420 1160 720 1160 {lab=VDD}
N 720 1160 1170 1160 {lab=VDD}
N 1170 1160 1570 1160 {lab=VDD}
N 1570 1160 2100 1160 {lab=VDD}
N 2100 1160 2570 1160 {lab=VDD}
N 2570 1160 3030 1160 {lab=VDD}
N 3030 1160 3450 1160 {lab=VDD}
N 3450 1160 3910 1160 {lab=VDD}
N 3910 1160 4370 1160 {lab=VDD}
N 4370 1160 4780 1160 {lab=VDD}
N 4780 1160 5310 1160 {lab=VDD}
N 5310 1160 5710 1160 {lab=VDD}
N 5710 1160 6220 1160 {lab=VDD}
N 720 1290 1170 1290 {lab=VSS}
N 1170 1290 1570 1290 {lab=VSS}
N 1570 1290 2100 1290 {lab=VSS}
N 2100 1290 2570 1290 {lab=VSS}
N 2570 1290 3030 1290 {lab=VSS}
N 3030 1290 3450 1290 {lab=VSS}
N 3450 1290 3910 1290 {lab=VSS}
N 3910 1290 4370 1290 {lab=VSS}
N 4370 1290 4780 1290 {lab=VSS}
N 4780 1290 5310 1290 {lab=VSS}
N 5310 1290 5710 1290 {lab=VSS}
N 5710 1290 6220 1290 {lab=VSS}
N 6220 1290 6540 1290 {lab=VSS}
N 460 1580 460 1590 {lab=VSS}
N 910 1580 910 1590 {lab=VSS}
N 1400 1460 1400 1480 {lab=VDD}
N 1400 1560 1400 1590 {lab=VSS}
N 1830 1580 1830 1590 {lab=VSS}
N 2280 1580 2280 1590 {lab=VSS}
N 2770 1580 2770 1590 {lab=VSS}
N 3210 1580 3210 1590 {lab=VSS}
N 3640 1580 3640 1590 {lab=VSS}
N 4110 1460 4110 1480 {lab=VDD}
N 4110 1560 4110 1590 {lab=VSS}
N 4580 1460 4580 1480 {lab=VDD}
N 4580 1560 4580 1590 {lab=VSS}
N 5040 1580 5040 1590 {lab=VSS}
N 5510 1460 5510 1480 {lab=VDD}
N 5510 1560 5510 1590 {lab=VSS}
N 5950 1460 5950 1480 {lab=VDD}
N 5950 1560 5950 1590 {lab=VSS}
N 6410 1460 6410 1480 {lab=VDD}
N 6410 1560 6410 1590 {lab=VSS}
N 420 1460 460 1460 {lab=VDD}
N 460 1460 910 1460 {lab=VDD}
N 910 1460 1400 1460 {lab=VDD}
N 1400 1460 1830 1460 {lab=VDD}
N 1830 1460 2280 1460 {lab=VDD}
N 2280 1460 2770 1460 {lab=VDD}
N 2770 1460 3210 1460 {lab=VDD}
N 3210 1460 3640 1460 {lab=VDD}
N 3640 1460 4110 1460 {lab=VDD}
N 4110 1460 4580 1460 {lab=VDD}
N 4580 1460 5040 1460 {lab=VDD}
N 5040 1460 5510 1460 {lab=VDD}
N 5510 1460 5950 1460 {lab=VDD}
N 5950 1460 6410 1460 {lab=VDD}
N 460 1590 910 1590 {lab=VSS}
N 910 1590 1400 1590 {lab=VSS}
N 1400 1590 1830 1590 {lab=VSS}
N 1830 1590 2280 1590 {lab=VSS}
N 2280 1590 2770 1590 {lab=VSS}
N 2770 1590 3210 1590 {lab=VSS}
N 3210 1590 3640 1590 {lab=VSS}
N 3640 1590 4110 1590 {lab=VSS}
N 4110 1590 4580 1590 {lab=VSS}
N 4580 1590 5040 1590 {lab=VSS}
N 5040 1590 5510 1590 {lab=VSS}
N 5510 1590 5950 1590 {lab=VSS}
N 5950 1590 6410 1590 {lab=VSS}
N 6410 1590 6540 1590 {lab=VSS}
N 780 1740 780 1760 {lab=VDD}
N 780 1840 780 1870 {lab=VSS}
N 1230 1860 1230 1870 {lab=VSS}
N 1630 1860 1630 1870 {lab=VSS}
N 2090 1860 2090 1870 {lab=VSS}
N 2570 1860 2570 1870 {lab=VSS}
N 3030 1740 3030 1760 {lab=VDD}
N 3030 1840 3030 1870 {lab=VSS}
N 3450 1860 3450 1870 {lab=VSS}
N 3900 1860 3900 1870 {lab=VSS}
N 4370 1740 4370 1760 {lab=VDD}
N 4370 1840 4370 1870 {lab=VSS}
N 4840 1860 4840 1870 {lab=VSS}
N 5240 1860 5240 1870 {lab=VSS}
N 5770 1860 5770 1870 {lab=VSS}
N 6210 1860 6210 1870 {lab=VSS}
N 420 1740 780 1740 {lab=VDD}
N 780 1740 1230 1740 {lab=VDD}
N 1230 1740 1630 1740 {lab=VDD}
N 1630 1740 2090 1740 {lab=VDD}
N 2090 1740 2570 1740 {lab=VDD}
N 2570 1740 3030 1740 {lab=VDD}
N 3030 1740 3450 1740 {lab=VDD}
N 3450 1740 3900 1740 {lab=VDD}
N 3900 1740 4370 1740 {lab=VDD}
N 4370 1740 4840 1740 {lab=VDD}
N 4840 1740 5240 1740 {lab=VDD}
N 5240 1740 5770 1740 {lab=VDD}
N 5770 1740 6210 1740 {lab=VDD}
N 780 1870 1230 1870 {lab=VSS}
N 1230 1870 1630 1870 {lab=VSS}
N 1630 1870 2090 1870 {lab=VSS}
N 2090 1870 2570 1870 {lab=VSS}
N 2570 1870 3030 1870 {lab=VSS}
N 3030 1870 3450 1870 {lab=VSS}
N 3450 1870 3900 1870 {lab=VSS}
N 3900 1870 4370 1870 {lab=VSS}
N 4370 1870 4840 1870 {lab=VSS}
N 4840 1870 5240 1870 {lab=VSS}
N 5240 1870 5770 1870 {lab=VSS}
N 5770 1870 6210 1870 {lab=VSS}
N 6210 1870 6540 1870 {lab=VSS}
N 460 2160 460 2170 {lab=VSS}
N 970 2160 970 2170 {lab=VSS}
N 1390 2160 1390 2170 {lab=VSS}
N 1830 2160 1830 2170 {lab=VSS}
N 2280 2160 2280 2170 {lab=VSS}
N 2770 2160 2770 2170 {lab=VSS}
N 3210 2160 3210 2170 {lab=VSS}
N 3580 2160 3580 2170 {lab=VSS}
N 4100 2160 4100 2170 {lab=VSS}
N 4570 2160 4570 2170 {lab=VSS}
N 5040 2160 5040 2170 {lab=VSS}
N 5440 2160 5440 2170 {lab=VSS}
N 5940 2160 5940 2170 {lab=VSS}
N 6340 2160 6340 2170 {lab=VSS}
N 420 2040 460 2040 {lab=VDD}
N 460 2040 970 2040 {lab=VDD}
N 970 2040 1390 2040 {lab=VDD}
N 1390 2040 1830 2040 {lab=VDD}
N 1830 2040 2280 2040 {lab=VDD}
N 2280 2040 2770 2040 {lab=VDD}
N 2770 2040 3210 2040 {lab=VDD}
N 3210 2040 3580 2040 {lab=VDD}
N 3580 2040 4100 2040 {lab=VDD}
N 4100 2040 4570 2040 {lab=VDD}
N 4570 2040 5040 2040 {lab=VDD}
N 5040 2040 5440 2040 {lab=VDD}
N 5440 2040 5940 2040 {lab=VDD}
N 5940 2040 6340 2040 {lab=VDD}
N 460 2170 970 2170 {lab=VSS}
N 970 2170 1390 2170 {lab=VSS}
N 1390 2170 1830 2170 {lab=VSS}
N 1830 2170 2280 2170 {lab=VSS}
N 2280 2170 2770 2170 {lab=VSS}
N 2770 2170 3210 2170 {lab=VSS}
N 3210 2170 3580 2170 {lab=VSS}
N 3580 2170 4100 2170 {lab=VSS}
N 4100 2170 4570 2170 {lab=VSS}
N 4570 2170 5040 2170 {lab=VSS}
N 5040 2170 5440 2170 {lab=VSS}
N 5440 2170 5940 2170 {lab=VSS}
N 5940 2170 6340 2170 {lab=VSS}
N 6340 2170 6540 2170 {lab=VSS}
N 570 2460 570 2470 {lab=VSS}
N 1020 2460 1020 2470 {lab=VSS}
N 1380 2460 1380 2470 {lab=VSS}
N 1800 2460 1800 2470 {lab=VSS}
N 2330 2460 2330 2470 {lab=VSS}
N 2820 2460 2820 2470 {lab=VSS}
N 3270 2340 3270 2360 {lab=VDD}
N 3270 2440 3270 2470 {lab=VSS}
N 3690 2460 3690 2470 {lab=VSS}
N 4150 2460 4150 2470 {lab=VSS}
N 4620 2460 4620 2470 {lab=VSS}
N 5090 2460 5090 2470 {lab=VSS}
N 5550 2460 5550 2470 {lab=VSS}
N 5990 2460 5990 2470 {lab=VSS}
N 6450 2460 6450 2470 {lab=VSS}
N 420 2340 570 2340 {lab=VDD}
N 570 2340 1020 2340 {lab=VDD}
N 1020 2340 1380 2340 {lab=VDD}
N 1380 2340 1800 2340 {lab=VDD}
N 1800 2340 2330 2340 {lab=VDD}
N 2330 2340 2820 2340 {lab=VDD}
N 2820 2340 3270 2340 {lab=VDD}
N 3270 2340 3690 2340 {lab=VDD}
N 3690 2340 4150 2340 {lab=VDD}
N 4150 2340 4620 2340 {lab=VDD}
N 4620 2340 5090 2340 {lab=VDD}
N 5090 2340 5550 2340 {lab=VDD}
N 5550 2340 5990 2340 {lab=VDD}
N 5990 2340 6450 2340 {lab=VDD}
N 570 2470 1020 2470 {lab=VSS}
N 1020 2470 1380 2470 {lab=VSS}
N 1380 2470 1800 2470 {lab=VSS}
N 1800 2470 2330 2470 {lab=VSS}
N 2330 2470 2820 2470 {lab=VSS}
N 2820 2470 3270 2470 {lab=VSS}
N 3270 2470 3690 2470 {lab=VSS}
N 3690 2470 4150 2470 {lab=VSS}
N 4150 2470 4620 2470 {lab=VSS}
N 4620 2470 5090 2470 {lab=VSS}
N 5090 2470 5550 2470 {lab=VSS}
N 5550 2470 5990 2470 {lab=VSS}
N 5990 2470 6450 2470 {lab=VSS}
N 6450 2470 6540 2470 {lab=VSS}
N 670 2790 670 2800 {lab=VSS}
N 1120 2790 1120 2800 {lab=VSS}
N 1580 2790 1580 2800 {lab=VSS}
N 2040 2790 2040 2800 {lab=VSS}
N 2520 2790 2520 2800 {lab=VSS}
N 2980 2790 2980 2800 {lab=VSS}
N 3400 2790 3400 2800 {lab=VSS}
N 3850 2790 3850 2800 {lab=VSS}
N 4310 2790 4310 2800 {lab=VSS}
N 4790 2790 4790 2800 {lab=VSS}
N 5250 2790 5250 2800 {lab=VSS}
N 5720 2790 5720 2800 {lab=VSS}
N 6160 2790 6160 2800 {lab=VSS}
N 420 2670 670 2670 {lab=VDD}
N 670 2670 1120 2670 {lab=VDD}
N 1120 2670 1580 2670 {lab=VDD}
N 1580 2670 2040 2670 {lab=VDD}
N 2040 2670 2520 2670 {lab=VDD}
N 2520 2670 2980 2670 {lab=VDD}
N 2980 2670 3400 2670 {lab=VDD}
N 3400 2670 3850 2670 {lab=VDD}
N 3850 2670 4310 2670 {lab=VDD}
N 4310 2670 4790 2670 {lab=VDD}
N 4790 2670 5250 2670 {lab=VDD}
N 5250 2670 5720 2670 {lab=VDD}
N 5720 2670 6160 2670 {lab=VDD}
N 670 2800 1120 2800 {lab=VSS}
N 1120 2800 1580 2800 {lab=VSS}
N 1580 2800 2040 2800 {lab=VSS}
N 2040 2800 2520 2800 {lab=VSS}
N 2520 2800 2980 2800 {lab=VSS}
N 2980 2800 3400 2800 {lab=VSS}
N 3400 2800 3850 2800 {lab=VSS}
N 3850 2800 4310 2800 {lab=VSS}
N 4310 2800 4790 2800 {lab=VSS}
N 4790 2800 5250 2800 {lab=VSS}
N 5250 2800 5720 2800 {lab=VSS}
N 5720 2800 6160 2800 {lab=VSS}
N 6160 2800 6540 2800 {lab=VSS}
N 420 300 420 610 {lab=VDD}
N 420 610 420 900 {lab=VDD}
N 420 900 420 1160 {lab=VDD}
N 420 1160 420 1460 {lab=VDD}
N 420 1460 420 1740 {lab=VDD}
N 420 1740 420 2040 {lab=VDD}
N 420 2040 420 2340 {lab=VDD}
N 420 2340 420 2670 {lab=VDD}
N 6540 420 6540 740 {lab=VSS}
N 6540 740 6540 1030 {lab=VSS}
N 6540 1030 6540 1290 {lab=VSS}
N 6540 1290 6540 1590 {lab=VSS}
N 6540 1590 6540 1870 {lab=VSS}
N 6540 1870 6540 2170 {lab=VSS}
N 6540 2170 6540 2470 {lab=VSS}
N 6540 2470 6540 2800 {lab=VSS}
N 4980 2390 5040 2390 {lab=#net1}
N 4980 2190 4980 2390 {lab=#net1}
N 4500 2430 4570 2430 {lab=#net1}
N 4500 2190 4500 2430 {lab=#net1}
N 5440 2380 5500 2380 {lab=#net1}
N 5440 2190 5440 2380 {lab=#net1}
N 5500 2070 5580 2070 {lab=#net1}
N 5580 2070 5580 2190 {lab=#net1}
N 4500 2190 4980 2190 {lab=#net1}
N 4980 2190 5440 2190 {lab=#net1}
N 5440 2190 5580 2190 {lab=#net1}
N 4040 2370 4100 2370 {lab=#net2}
N 4040 2200 4040 2370 {lab=#net2}
N 6340 2370 6400 2370 {lab=#net2}
N 6340 2200 6340 2370 {lab=#net2}
N 5860 2080 5890 2080 {lab=#net2}
N 5860 2080 5860 2200 {lab=#net2}
N 5500 2110 5590 2110 {lab=#net2}
N 5590 2110 5590 2200 {lab=#net2}
N 4040 2200 5590 2200 {lab=#net2}
N 5590 2200 5860 2200 {lab=#net2}
N 5860 2200 6340 2200 {lab=#net2}
N 3640 2070 3710 2070 {lab=#net3}
N 4030 2390 4100 2390 {lab=#net4}
N 4030 2210 4030 2390 {lab=#net4}
N 4990 2370 5040 2370 {lab=#net4}
N 4990 2210 4990 2370 {lab=#net4}
N 4520 2370 4570 2370 {lab=#net4}
N 4520 2210 4520 2370 {lab=#net4}
N 6330 2390 6400 2390 {lab=#net4}
N 6330 2210 6330 2390 {lab=#net4}
N 3640 2110 3740 2110 {lab=#net4}
N 3740 2110 3740 2210 {lab=#net4}
N 3740 2210 4030 2210 {lab=#net4}
N 4030 2210 4520 2210 {lab=#net4}
N 4520 2210 4990 2210 {lab=#net4}
N 4990 2210 6330 2210 {lab=#net4}
N 4010 2430 4100 2430 {lab=#net5}
N 4010 2220 4010 2430 {lab=#net5}
N 4970 2410 5040 2410 {lab=#net5}
N 4970 2220 4970 2410 {lab=#net5}
N 4480 2410 4570 2410 {lab=#net5}
N 4480 2220 4480 2410 {lab=#net5}
N 4480 2100 4520 2100 {lab=#net5}
N 4480 2100 4480 2220 {lab=#net5}
N 5430 2420 5500 2420 {lab=#net5}
N 5430 2220 5430 2420 {lab=#net5}
N 5880 2120 5890 2120 {lab=#net5}
N 5880 2120 5880 2220 {lab=#net5}
N 4970 2080 4990 2080 {lab=#net5}
N 4970 2080 4970 2220 {lab=#net5}
N 1440 2370 1470 2370 {lab=#net5}
N 1470 2220 1470 2370 {lab=#net5}
N 1470 2220 4010 2220 {lab=#net5}
N 4010 2220 4480 2220 {lab=#net5}
N 4480 2220 4970 2220 {lab=#net5}
N 4970 2220 5430 2220 {lab=#net5}
N 5430 2220 5880 2220 {lab=#net5}
N 6320 2410 6400 2410 {lab=#net6}
N 6320 2230 6320 2410 {lab=#net6}
N 900 2090 920 2090 {lab=#net6}
N 2700 2080 2720 2080 {lab=#net6}
N 2700 2080 2700 2230 {lab=#net6}
N 2220 2080 2230 2080 {lab=#net6}
N 2220 2080 2220 2230 {lab=#net6}
N 3580 2380 3640 2380 {lab=#net6}
N 3580 2230 3580 2380 {lab=#net6}
N 2710 2390 2770 2390 {lab=#net6}
N 2710 2230 2710 2390 {lab=#net6}
N 1440 2410 1480 2410 {lab=#net6}
N 1480 2230 1480 2410 {lab=#net6}
N 900 2230 1480 2230 {lab=#net6}
N 1480 2230 2220 2230 {lab=#net6}
N 2220 2230 2700 2230 {lab=#net6}
N 2700 2230 2710 2230 {lab=#net6}
N 2710 2230 3580 2230 {lab=#net6}
N 3580 2230 6320 2230 {lab=#net6}
N 4960 2430 5040 2430 {lab=#net7}
N 4960 2240 4960 2430 {lab=#net7}
N 5860 2430 5950 2430 {lab=#net7}
N 5860 2240 5860 2430 {lab=#net7}
N 4960 2120 4990 2120 {lab=#net7}
N 4960 2120 4960 2240 {lab=#net7}
N 3570 2420 3640 2420 {lab=#net7}
N 3570 2240 3570 2420 {lab=#net7}
N 1860 2370 1930 2370 {lab=#net7}
N 1930 2240 1930 2370 {lab=#net7}
N 1930 2240 3570 2240 {lab=#net7}
N 3570 2240 4960 2240 {lab=#net7}
N 4960 2240 5860 2240 {lab=#net7}
N 4020 2410 4100 2410 {lab=#net8}
N 4020 2250 4020 2410 {lab=#net8}
N 4510 2390 4570 2390 {lab=#net8}
N 4510 2250 4510 2390 {lab=#net8}
N 890 2070 920 2070 {lab=#net8}
N 2690 2100 2720 2100 {lab=#net8}
N 2690 2100 2690 2250 {lab=#net8}
N 2210 2100 2230 2100 {lab=#net8}
N 2210 2100 2210 2250 {lab=#net8}
N 2700 2410 2770 2410 {lab=#net8}
N 2700 2250 2700 2410 {lab=#net8}
N 1860 2410 1940 2410 {lab=#net8}
N 1940 2250 1940 2410 {lab=#net8}
N 890 2250 1940 2250 {lab=#net8}
N 1940 2250 2210 2250 {lab=#net8}
N 2210 2250 2690 2250 {lab=#net8}
N 2690 2250 2700 2250 {lab=#net8}
N 2700 2250 4020 2250 {lab=#net8}
N 4020 2250 4510 2250 {lab=#net8}
N 1040 360 1100 360 {lab=#net9}
N 1100 360 1100 430 {lab=#net9}
N 3150 360 3160 360 {lab=#net9}
N 3150 360 3150 430 {lab=#net9}
N 1100 430 3150 430 {lab=#net9}
N 3280 360 3300 360 {lab=#net10}
N 3300 360 3300 430 {lab=#net10}
N 3570 360 3590 360 {lab=#net10}
N 3570 360 3570 430 {lab=#net10}
N 3300 430 3570 430 {lab=#net10}
N 3710 360 3770 360 {lab=#net11}
N 3770 360 3770 430 {lab=#net11}
N 4020 360 4050 360 {lab=#net11}
N 4020 360 4020 430 {lab=#net11}
N 3770 430 4020 430 {lab=#net11}
N 4170 360 4230 360 {lab=#net12}
N 4230 360 4230 430 {lab=#net12}
N 4230 430 6550 430 {lab=#net12}
N 2930 1800 2980 1800 {lab=#net12}
N 2930 1730 2930 1800 {lab=#net12}
N 2930 1730 3330 1730 {lab=#net12}
N 3330 1730 6550 1730 {lab=#net12}
N 6550 430 6550 1730 {lab=#net12}
N 4970 340 4990 340 {lab=#net13}
N 4970 340 4970 440 {lab=#net13}
N 2220 340 2230 340 {lab=#net13}
N 2220 340 2220 440 {lab=#net13}
N 2220 440 4970 440 {lab=#net13}
N 4970 440 6560 440 {lab=#net13}
N 2700 940 2720 940 {lab=#net13}
N 2700 890 2700 940 {lab=#net13}
N 2700 890 6560 890 {lab=#net13}
N 3980 1800 4010 1800 {lab=#net13}
N 4010 1800 4010 1880 {lab=#net13}
N 6100 1820 6160 1820 {lab=#net13}
N 6100 1820 6100 1880 {lab=#net13}
N 4010 1880 6100 1880 {lab=#net13}
N 6100 1880 6560 1880 {lab=#net13}
N 6560 440 6560 600 {lab=#net13}
N 6560 600 6560 890 {lab=#net13}
N 6560 890 6560 1880 {lab=#net13}
N 4650 960 4720 960 {lab=#net14}
N 4720 960 4720 1040 {lab=#net14}
N 4720 1040 6570 1040 {lab=#net14}
N 2460 1800 2520 1800 {lab=#net14}
N 2460 1720 2460 1800 {lab=#net14}
N 2460 1720 6570 1720 {lab=#net14}
N 6570 1040 6570 1720 {lab=#net14}
N 2850 1520 2910 1520 {lab=#net15}
N 2910 1520 2910 1670 {lab=#net15}
N 2450 1820 2520 1820 {lab=#net15}
N 2450 1670 2450 1820 {lab=#net15}
N 2450 1670 2910 1670 {lab=#net15}
N 2190 670 2220 670 {lab=#net16}
N 2220 510 2220 670 {lab=#net16}
N 4960 380 4990 380 {lab=#net16}
N 4960 380 4960 510 {lab=#net16}
N 2220 510 4960 510 {lab=#net16}
N 5120 360 5180 360 {lab=#net17}
N 5180 360 5180 450 {lab=#net17}
N 6300 340 6350 340 {lab=#net17}
N 6300 340 6300 450 {lab=#net17}
N 5400 340 5450 340 {lab=#net17}
N 5400 340 5400 450 {lab=#net17}
N 5180 450 5400 450 {lab=#net17}
N 5400 450 6300 450 {lab=#net17}
N 6290 670 6300 670 {lab=#net18}
N 6300 510 6300 670 {lab=#net18}
N 6290 380 6350 380 {lab=#net18}
N 6290 380 6290 510 {lab=#net18}
N 5860 340 5890 340 {lab=#net18}
N 5860 340 5860 510 {lab=#net18}
N 5860 510 6290 510 {lab=#net18}
N 6290 510 6300 510 {lab=#net18}
N 5580 960 5630 960 {lab=#net19}
N 5630 880 5630 960 {lab=#net19}
N 5870 940 5890 940 {lab=#net19}
N 5870 880 5870 940 {lab=#net19}
N 5630 880 5870 880 {lab=#net19}
N 5850 670 5870 670 {lab=#net20}
N 5870 670 5870 770 {lab=#net20}
N 5850 980 5890 980 {lab=#net20}
N 5850 770 5850 980 {lab=#net20}
N 5850 770 5870 770 {lab=#net20}
N 3100 1800 3130 1800 {lab=#net21}
N 3130 1800 3130 1880 {lab=#net21}
N 1970 1780 2040 1780 {lab=#net21}
N 1970 1780 1970 1880 {lab=#net21}
N 1970 1880 3130 1880 {lab=#net21}
N 6440 1520 6490 1520 {lab=#net22}
N 6490 1450 6490 1520 {lab=#net22}
N 4020 1500 4050 1500 {lab=#net22}
N 4020 1450 4020 1500 {lab=#net22}
N 4020 1450 6490 1450 {lab=#net22}
N 3940 1220 4000 1220 {lab=#net23}
N 4000 1220 4000 1330 {lab=#net23}
N 4010 1540 4050 1540 {lab=#net23}
N 4010 1330 4010 1540 {lab=#net23}
N 4000 1330 4010 1330 {lab=#net23}
N 4140 1520 4200 1520 {lab=#net24}
N 4200 1520 4200 1600 {lab=#net24}
N 4490 1500 4520 1500 {lab=#net24}
N 4490 1500 4490 1600 {lab=#net24}
N 4200 1600 4490 1600 {lab=#net24}
N 5980 1520 6020 1520 {lab=#net25}
N 6020 1440 6020 1520 {lab=#net25}
N 4970 1500 4990 1500 {lab=#net25}
N 4970 1440 4970 1500 {lab=#net25}
N 4970 1440 6020 1440 {lab=#net25}
N 5120 1520 5180 1520 {lab=#net26}
N 5180 1520 5180 1610 {lab=#net26}
N 4480 1540 4520 1540 {lab=#net26}
N 4480 1540 4480 1610 {lab=#net26}
N 4480 1610 5180 1610 {lab=#net26}
N 4610 1520 4650 1520 {lab=#net27}
N 4650 1520 4650 1670 {lab=#net27}
N 4730 1780 4790 1780 {lab=#net27}
N 4730 1670 4730 1780 {lab=#net27}
N 4650 1670 4730 1670 {lab=#net27}
N 4940 1800 4960 1800 {lab=#net28}
N 4960 1710 4960 1800 {lab=#net28}
N 4260 1780 4310 1780 {lab=#net28}
N 4260 1710 4260 1780 {lab=#net28}
N 4260 1710 4960 1710 {lab=#net28}
N 3740 1520 3780 1520 {lab=#net29}
N 3780 1520 3780 1670 {lab=#net29}
N 4250 1820 4310 1820 {lab=#net29}
N 4250 1670 4250 1820 {lab=#net29}
N 3780 1670 4250 1670 {lab=#net29}
N 2430 2400 2440 2400 {lab=#net30}
N 2440 2260 2440 2400 {lab=#net30}
N 4490 2080 4520 2080 {lab=#net30}
N 4490 2080 4490 2260 {lab=#net30}
N 2720 2370 2770 2370 {lab=#net30}
N 2720 2260 2720 2370 {lab=#net30}
N 2440 2260 2720 2260 {lab=#net30}
N 2720 2260 4490 2260 {lab=#net30}
N 4650 2100 4720 2100 {lab=#net31}
N 4720 2100 4720 2260 {lab=#net31}
N 5880 2390 5950 2390 {lab=#net31}
N 4720 2260 5880 2260 {lab=#net31}
N 5630 2330 5630 2400 {lab=#net32}
N 5870 2370 5950 2370 {lab=#net32}
N 5630 2330 5870 2330 {lab=#net32}
N 6530 2400 6530 2480 {lab=#net33}
N 5870 2410 5950 2410 {lab=#net33}
N 5870 2410 5870 2480 {lab=#net33}
N 5870 2480 6530 2480 {lab=#net33}
N 5140 960 5180 960 {lab=#net34}
N 5180 960 5180 1060 {lab=#net34}
N 3350 1190 3400 1190 {lab=#net34}
N 3350 1060 3350 1190 {lab=#net34}
N 3350 1060 5180 1060 {lab=#net34}
N 590 960 650 960 {lab=#net35}
N 650 960 650 1070 {lab=#net35}
N 3340 1210 3400 1210 {lab=#net35}
N 3340 1070 3340 1210 {lab=#net35}
N 650 1070 3340 1070 {lab=#net35}
N 3530 1220 3550 1220 {lab=#net36}
N 3550 1220 3550 1330 {lab=#net36}
N 1730 1550 1780 1550 {lab=#net36}
N 1730 1330 1730 1550 {lab=#net36}
N 1730 1330 3550 1330 {lab=#net36}
N 1910 1520 1940 1520 {lab=#net37}
N 1940 1520 1940 1670 {lab=#net37}
N 1510 1780 1580 1780 {lab=#net37}
N 1510 1670 1510 1780 {lab=#net37}
N 1510 1670 1940 1670 {lab=#net37}
N 6020 360 6080 360 {lab=#net38}
N 6080 360 6080 460 {lab=#net38}
N 5380 380 5450 380 {lab=#net38}
N 5380 380 5380 460 {lab=#net38}
N 5380 460 6080 460 {lab=#net38}
N 5580 360 5630 360 {lab=#net39}
N 5630 360 5630 520 {lab=#net39}
N 1720 340 1780 340 {lab=#net39}
N 1720 340 1720 520 {lab=#net39}
N 1530 650 1580 650 {lab=#net39}
N 1530 520 1530 650 {lab=#net39}
N 1530 520 1720 520 {lab=#net39}
N 1720 520 5630 520 {lab=#net39}
N 1910 360 1950 360 {lab=#net40}
N 1950 360 1950 530 {lab=#net40}
N 1110 640 1170 640 {lab=#net40}
N 1110 530 1110 640 {lab=#net40}
N 1110 530 1950 530 {lab=#net40}
N 1710 670 1740 670 {lab=#net41}
N 1740 670 1740 780 {lab=#net41}
N 2190 940 2230 940 {lab=#net41}
N 2190 780 2190 940 {lab=#net41}
N 1740 780 2190 780 {lab=#net41}
N 2360 960 2440 960 {lab=#net42}
N 2440 960 2440 1040 {lab=#net42}
N 1750 930 1770 930 {lab=#net42}
N 1750 930 1750 1040 {lab=#net42}
N 1750 1040 2440 1040 {lab=#net42}
N 6020 2100 6080 2100 {lab=#net43}
N 6080 1930 6080 2100 {lab=#net43}
N 4000 2080 4050 2080 {lab=#net43}
N 4000 1930 4000 2080 {lab=#net43}
N 6110 1780 6160 1780 {lab=#net43}
N 6110 1780 6110 1930 {lab=#net43}
N 4000 1930 6080 1930 {lab=#net43}
N 6080 1930 6110 1930 {lab=#net43}
N 5120 2100 5180 2100 {lab=#net44}
N 5180 1940 5180 2100 {lab=#net44}
N 3990 2120 4050 2120 {lab=#net44}
N 5630 1820 5720 1820 {lab=#net44}
N 5630 1820 5630 1940 {lab=#net44}
N 3990 1940 5180 1940 {lab=#net44}
N 5180 1940 5630 1940 {lab=#net44}
N 2850 2100 2910 2100 {lab=#net45}
N 2910 2030 2910 2100 {lab=#net45}
N 3980 2100 4050 2100 {lab=#net45}
N 2910 2030 3980 2030 {lab=#net45}
N 4180 2100 4240 2100 {lab=#net46}
N 4240 2100 4240 2270 {lab=#net46}
N 1340 2370 1380 2370 {lab=#net46}
N 1340 2270 1340 2370 {lab=#net46}
N 1340 2270 4240 2270 {lab=#net46}
N 2360 2100 2430 2100 {lab=#net47}
N 2430 2100 2430 2280 {lab=#net47}
N 1760 2370 1800 2370 {lab=#net47}
N 1760 2280 1760 2370 {lab=#net47}
N 1760 2280 2430 2280 {lab=#net47}
N 6290 1800 6300 1800 {lab=#net48}
N 6300 1800 6300 1890 {lab=#net48}
N 5640 1780 5720 1780 {lab=#net48}
N 5640 1780 5640 1890 {lab=#net48}
N 5640 1890 6300 1890 {lab=#net48}
N 5850 1800 5880 1800 {lab=#net49}
N 5880 1800 5880 1950 {lab=#net49}
N 5420 2070 5440 2070 {lab=#net49}
N 5420 1950 5420 2070 {lab=#net49}
N 5420 1950 5880 1950 {lab=#net49}
N 3770 2400 3780 2400 {lab=#net50}
N 3780 2280 3780 2400 {lab=#net50}
N 3560 2070 3580 2070 {lab=#net50}
N 3560 2070 3560 2280 {lab=#net50}
N 3560 2280 3780 2280 {lab=#net50}
N 2360 360 2430 360 {lab=#net51}
N 2430 360 2430 460 {lab=#net51}
N 410 460 2430 460 {lab=#net51}
N 2080 1260 2080 1280 {lab=#net51}
N 2080 1280 2200 1280 {lab=#net51}
N 2200 1150 2200 1280 {lab=#net51}
N 4350 1260 4350 1280 {lab=#net51}
N 4350 1280 4470 1280 {lab=#net51}
N 4470 1150 4470 1280 {lab=#net51}
N 410 1150 2200 1150 {lab=#net51}
N 2200 1150 4470 1150 {lab=#net51}
N 410 460 410 1150 {lab=#net51}
N 2130 1220 2190 1220 {lab=#net52}
N 2190 1220 2190 1300 {lab=#net52}
N 1520 1190 1570 1190 {lab=#net52}
N 1520 1190 1520 1300 {lab=#net52}
N 1520 1300 2190 1300 {lab=#net52}
N 4400 1220 4460 1220 {lab=#net53}
N 4460 1220 4460 1340 {lab=#net53}
N 440 1490 460 1490 {lab=#net53}
N 440 1340 440 1490 {lab=#net53}
N 440 1340 4460 1340 {lab=#net53}
N 2850 960 2910 960 {lab=#net54}
N 2910 880 2910 960 {lab=#net54}
N 1380 1000 1380 1020 {lab=#net54}
N 1380 1020 1480 1020 {lab=#net54}
N 1480 880 1480 1020 {lab=#net54}
N 960 1000 960 1020 {lab=#net54}
N 960 1020 1100 1020 {lab=#net54}
N 1100 880 1100 1020 {lab=#net54}
N 1100 880 1480 880 {lab=#net54}
N 1480 880 2910 880 {lab=#net54}
N 1430 960 1470 960 {lab=#net55}
N 1470 960 1470 1080 {lab=#net55}
N 1110 1190 1170 1190 {lab=#net55}
N 1110 1080 1110 1190 {lab=#net55}
N 1110 1080 1470 1080 {lab=#net55}
N 1010 960 1060 960 {lab=#net56}
N 1060 960 1060 1080 {lab=#net56}
N 660 1190 720 1190 {lab=#net56}
N 660 1080 660 1190 {lab=#net56}
N 660 1080 1060 1080 {lab=#net56}
N 3110 1220 3140 1220 {lab=#net57}
N 3140 1220 3140 1350 {lab=#net57}
N 3130 1550 3160 1550 {lab=#net57}
N 3130 1350 3130 1550 {lab=#net57}
N 3130 1350 3140 1350 {lab=#net57}
N 3290 1520 3300 1520 {lab=#net58}
N 3300 1350 3300 1520 {lab=#net58}
N 5490 1560 5490 1580 {lab=#net58}
N 5490 1580 5630 1580 {lab=#net58}
N 5630 1350 5630 1580 {lab=#net58}
N 6200 1260 6200 1280 {lab=#net58}
N 6200 1280 6300 1280 {lab=#net58}
N 6300 1280 6300 1350 {lab=#net58}
N 3300 1350 5630 1350 {lab=#net58}
N 5630 1350 6300 1350 {lab=#net58}
N 5540 1520 5600 1520 {lab=#net59}
N 5600 1520 5600 1670 {lab=#net59}
N 5190 1770 5240 1770 {lab=#net59}
N 5190 1670 5190 1770 {lab=#net59}
N 5190 1670 5600 1670 {lab=#net59}
N 6250 1220 6300 1220 {lab=#net60}
N 6300 1150 6300 1220 {lab=#net60}
N 5660 1190 5710 1190 {lab=#net60}
N 5660 1150 5660 1190 {lab=#net60}
N 5660 1150 6300 1150 {lab=#net60}
N 2650 1220 2680 1220 {lab=#net61}
N 2680 1220 2680 1350 {lab=#net61}
N 2190 1550 2230 1550 {lab=#net61}
N 2190 1350 2190 1550 {lab=#net61}
N 2190 1350 2680 1350 {lab=#net61}
N 2360 1520 2430 1520 {lab=#net62}
N 2430 1360 2430 1520 {lab=#net62}
N 1380 1560 1380 1580 {lab=#net62}
N 1380 1580 1480 1580 {lab=#net62}
N 1480 1360 1480 1580 {lab=#net62}
N 5290 1260 5290 1280 {lab=#net62}
N 5290 1280 5410 1280 {lab=#net62}
N 5410 1280 5410 1360 {lab=#net62}
N 1480 1360 2430 1360 {lab=#net62}
N 2430 1360 5410 1360 {lab=#net62}
N 1430 1520 1470 1520 {lab=#net63}
N 1470 1440 1470 1520 {lab=#net63}
N 890 1490 910 1490 {lab=#net63}
N 890 1440 890 1490 {lab=#net63}
N 890 1440 1470 1440 {lab=#net63}
N 5340 1220 5400 1220 {lab=#net64}
N 5400 1220 5400 1300 {lab=#net64}
N 4730 1190 4780 1190 {lab=#net64}
N 4730 1190 4730 1300 {lab=#net64}
N 4730 1300 5400 1300 {lab=#net64}
N 2900 2400 2910 2400 {lab=#net65}
N 2910 2400 2910 2490 {lab=#net65}
N 3310 2710 3350 2710 {lab=#net65}
N 3310 2490 3310 2710 {lab=#net65}
N 3150 2420 3210 2420 {lab=#net65}
N 3150 2420 3150 2490 {lab=#net65}
N 2910 2490 3150 2490 {lab=#net65}
N 3150 2490 3310 2490 {lab=#net65}
N 3480 2730 3550 2730 {lab=#net66}
N 3550 2660 3550 2730 {lab=#net66}
N 2910 2710 2930 2710 {lab=#net66}
N 2910 2660 2910 2710 {lab=#net66}
N 2910 2660 3550 2660 {lab=#net66}
N 3060 2730 3130 2730 {lab=#net67}
N 3130 2650 3130 2730 {lab=#net67}
N 2430 2750 2470 2750 {lab=#net67}
N 2430 2650 2430 2750 {lab=#net67}
N 2430 2650 3130 2650 {lab=#net67}
N 2600 2730 2670 2730 {lab=#net68}
N 2670 2640 2670 2730 {lab=#net68}
N 1520 2710 1530 2710 {lab=#net68}
N 1520 2640 1520 2710 {lab=#net68}
N 1520 2640 2670 2640 {lab=#net68}
N 1660 2730 1720 2730 {lab=#net69}
N 1720 2630 1720 2730 {lab=#net69}
N 1100 2700 1120 2700 {lab=#net69}
N 1100 2630 1100 2700 {lab=#net69}
N 1100 2630 1720 2630 {lab=#net69}
N 3300 2400 3320 2400 {lab=#net70}
N 3320 2400 3320 2490 {lab=#net70}
N 4720 2710 4740 2710 {lab=#net70}
N 4720 2490 4720 2710 {lab=#net70}
N 5650 2710 5670 2710 {lab=#net70}
N 5650 2490 5650 2710 {lab=#net70}
N 3320 2490 4720 2490 {lab=#net70}
N 4720 2490 5650 2490 {lab=#net70}
N 4870 2730 4950 2730 {lab=#net71}
N 4950 2630 4950 2730 {lab=#net71}
N 4230 2750 4260 2750 {lab=#net71}
N 4230 2630 4230 2750 {lab=#net71}
N 4230 2630 4950 2630 {lab=#net71}
N 4390 2730 4460 2730 {lab=#net72}
N 4460 2500 4460 2730 {lab=#net72}
N 910 2380 970 2380 {lab=#net72}
N 910 2380 910 2500 {lab=#net72}
N 910 2500 4460 2500 {lab=#net72}
N 1100 2280 1100 2400 {lab=#net73}
N 440 2070 460 2070 {lab=#net73}
N 440 2070 440 2280 {lab=#net73}
N 440 2280 1100 2280 {lab=#net73}
N 6240 2730 6300 2730 {lab=#net74}
N 6300 2630 6300 2730 {lab=#net74}
N 5640 2750 5670 2750 {lab=#net74}
N 5640 2630 5640 2750 {lab=#net74}
N 5640 2630 6300 2630 {lab=#net74}
N 5800 2730 5860 2730 {lab=#net75}
N 5860 2620 5860 2730 {lab=#net75}
N 5180 2710 5200 2710 {lab=#net75}
N 5180 2620 5180 2710 {lab=#net75}
N 5180 2620 5860 2620 {lab=#net75}
N 5330 2730 5400 2730 {lab=#net76}
N 5400 2610 5400 2730 {lab=#net76}
N 3770 2750 3800 2750 {lab=#net76}
N 3770 2610 3770 2750 {lab=#net76}
N 3770 2610 5400 2610 {lab=#net76}
N 3930 2730 4000 2730 {lab=#net77}
N 4000 2600 4000 2730 {lab=#net77}
N 1980 2710 1990 2710 {lab=#net77}
N 1980 2600 1980 2710 {lab=#net77}
N 1980 2600 4000 2600 {lab=#net77}
N 2120 2730 2190 2730 {lab=#net78}
N 2190 2590 2190 2730 {lab=#net78}
N 650 2700 670 2700 {lab=#net78}
N 650 2590 650 2700 {lab=#net78}
N 650 2590 2190 2590 {lab=#net78}
N 3980 670 4010 670 {lab=#net79}
N 4010 530 4010 670 {lab=#net79}
N 4460 340 4520 340 {lab=#net79}
N 4460 340 4460 530 {lab=#net79}
N 4010 530 4460 530 {lab=#net79}
N 4440 670 4470 670 {lab=#net80}
N 4470 540 4470 670 {lab=#net80}
N 4450 380 4520 380 {lab=#net80}
N 4450 540 4470 540 {lab=#net80}
N 5380 670 5410 670 {lab=#net81}
N 5410 550 5410 670 {lab=#net81}
N 4440 360 4520 360 {lab=#net81}
N 1310 340 1340 340 {lab=#net81}
N 1310 340 1310 550 {lab=#net81}
N 1310 550 4440 550 {lab=#net81}
N 4440 550 5410 550 {lab=#net81}
N 4650 360 4720 360 {lab=#net82}
N 4720 360 4720 560 {lab=#net82}
N 4730 640 4780 640 {lab=#net82}
N 4730 560 4730 640 {lab=#net82}
N 4720 560 4730 560 {lab=#net82}
N 3290 960 3300 960 {lab=#net83}
N 3300 960 3300 1040 {lab=#net83}
N 3550 940 3590 940 {lab=#net83}
N 3550 940 3550 1040 {lab=#net83}
N 3300 1040 3550 1040 {lab=#net83}
N 860 670 880 670 {lab=#net84}
N 880 670 880 790 {lab=#net84}
N 3540 980 3590 980 {lab=#net84}
N 880 790 3540 790 {lab=#net84}
N 3720 960 3780 960 {lab=#net85}
N 3780 880 3780 960 {lab=#net85}
N 4010 930 4040 930 {lab=#net85}
N 4010 880 4010 930 {lab=#net85}
N 3780 880 4010 880 {lab=#net85}
N 3530 670 3550 670 {lab=#net86}
N 3550 560 3550 670 {lab=#net86}
N 2670 340 2720 340 {lab=#net86}
N 2670 340 2670 560 {lab=#net86}
N 2670 560 3550 560 {lab=#net86}
N 1470 360 1480 360 {lab=#net87}
N 1480 360 1480 470 {lab=#net87}
N 2660 360 2720 360 {lab=#net87}
N 2660 360 2660 470 {lab=#net87}
N 1480 470 2660 470 {lab=#net87}
N 2650 670 2680 670 {lab=#net88}
N 2680 570 2680 670 {lab=#net88}
N 2650 380 2720 380 {lab=#net88}
N 2650 380 2650 570 {lab=#net88}
N 2650 570 2680 570 {lab=#net88}
N 2850 360 2910 360 {lab=#net89}
N 2910 360 2910 570 {lab=#net89}
N 2920 640 2970 640 {lab=#net89}
N 2920 570 2920 640 {lab=#net89}
N 2910 570 2920 570 {lab=#net89}
N 970 1530 1050 1530 {lab=gdata0_n}
N 1050 1530 1050 1620 {lab=gdata0_n}
N 6690 1460 6690 1620 {lab=gdata0_n}
N 1050 1620 6690 1620 {lab=gdata0_n}
N 4840 1230 4940 1230 {lab=gdata1_n}
N 4940 1140 4940 1230 {lab=gdata1_n}
N 6650 1140 6650 1160 {lab=gdata1_n}
N 4940 1140 6650 1140 {lab=gdata1_n}
N 6310 1500 6350 1500 {lab=gdirp0}
N 6310 1500 6310 1680 {lab=gdirp0}
N 5430 1500 5450 1500 {lab=gdirp0}
N 5430 1500 5430 1680 {lab=gdirp0}
N 5300 1770 5380 1770 {lab=gdirp0}
N 5380 1680 5380 1770 {lab=gdirp0}
N 6640 1520 6650 1520 {lab=gdirp0}
N 6640 1520 6640 1680 {lab=gdirp0}
N 5380 1680 5430 1680 {lab=gdirp0}
N 5430 1680 6310 1680 {lab=gdirp0}
N 6310 1680 6640 1680 {lab=gdirp0}
N 6300 1540 6350 1540 {lab=gdirp1}
N 6300 1360 6300 1540 {lab=gdirp1}
N 6110 1200 6160 1200 {lab=gdirp1}
N 6110 1200 6110 1360 {lab=gdirp1}
N 5770 1190 5850 1190 {lab=gdirp1}
N 5850 1190 5850 1360 {lab=gdirp1}
N 6640 1190 6650 1190 {lab=gdirp1}
N 6640 1190 6640 1360 {lab=gdirp1}
N 5850 1360 6110 1360 {lab=gdirp1}
N 6110 1360 6300 1360 {lab=gdirp1}
N 6300 1360 6640 1360 {lab=gdirp1}
N 1330 980 1340 980 {lab=gpio0_in}
N 1330 980 1330 1040 {lab=gpio0_in}
N 260 900 260 1040 {lab=gpio0_in}
N 260 1040 1330 1040 {lab=gpio0_in}
N 5300 1810 5390 1810 {lab=gpio0_oe}
N 5390 1710 5390 1810 {lab=gpio0_oe}
N 6640 1800 6650 1800 {lab=gpio0_oe}
N 6640 1710 6640 1800 {lab=gpio0_oe}
N 5390 1710 6640 1710 {lab=gpio0_oe}
N 5890 1430 5890 1500 {lab=gpio0_out}
N 1340 1430 1340 1500 {lab=gpio0_out}
N 970 1490 1050 1490 {lab=gpio0_out}
N 1050 1430 1050 1490 {lab=gpio0_out}
N 6630 1560 6650 1560 {lab=gpio0_out}
N 6630 1430 6630 1560 {lab=gpio0_out}
N 1050 1430 1340 1430 {lab=gpio0_out}
N 1340 1430 5890 1430 {lab=gpio0_out}
N 5890 1430 6630 1430 {lab=gpio0_out}
N 890 980 920 980 {lab=gpio1_in}
N 890 880 890 980 {lab=gpio1_in}
N 300 960 310 960 {lab=gpio1_in}
N 310 880 310 960 {lab=gpio1_in}
N 310 880 890 880 {lab=gpio1_in}
N 5770 1230 5860 1230 {lab=gpio1_oe}
N 5860 1230 5860 1300 {lab=gpio1_oe}
N 6610 1240 6650 1240 {lab=gpio1_oe}
N 6610 1240 6610 1300 {lab=gpio1_oe}
N 5860 1300 6610 1300 {lab=gpio1_oe}
N 5880 1540 5890 1540 {lab=gpio1_out}
N 5880 1370 5880 1540 {lab=gpio1_out}
N 5200 1200 5250 1200 {lab=gpio1_out}
N 5200 1200 5200 1370 {lab=gpio1_out}
N 4840 1190 4870 1190 {lab=gpio1_out}
N 4870 1190 4870 1370 {lab=gpio1_out}
N 6590 1280 6650 1280 {lab=gpio1_out}
N 6590 1280 6590 1370 {lab=gpio1_out}
N 4870 1370 5200 1370 {lab=gpio1_out}
N 5200 1370 5880 1370 {lab=gpio1_out}
N 5880 1370 6590 1370 {lab=gpio1_out}
N 1710 380 1780 380 {lab=#net90}
N 1710 380 1710 570 {lab=#net90}
N 1520 690 1580 690 {lab=#net90}
N 1520 570 1520 690 {lab=#net90}
N 2210 360 2230 360 {lab=#net90}
N 2210 360 2210 570 {lab=#net90}
N 1230 640 1310 640 {lab=#net90}
N 1310 570 1310 640 {lab=#net90}
N 1310 570 1520 570 {lab=#net90}
N 1520 570 1710 570 {lab=#net90}
N 1710 570 2210 570 {lab=#net90}
N 1990 650 2040 650 {lab=#net91}
N 1990 650 1990 750 {lab=#net91}
N 1230 680 1320 680 {lab=#net91}
N 1320 680 1320 750 {lab=#net91}
N 400 750 1320 750 {lab=#net91}
N 1320 750 1990 750 {lab=#net91}
N 4460 970 4520 970 {lab=#net91}
N 2690 960 2720 960 {lab=#net91}
N 2690 960 2690 1050 {lab=#net91}
N 400 1050 2690 1050 {lab=#net91}
N 2690 1050 4460 1050 {lab=#net91}
N 2930 1190 2980 1190 {lab=#net91}
N 2930 1140 2930 1190 {lab=#net91}
N 2470 1190 2520 1190 {lab=#net91}
N 2470 1140 2470 1190 {lab=#net91}
N 400 1140 2470 1140 {lab=#net91}
N 2470 1140 2930 1140 {lab=#net91}
N 2930 1140 3330 1140 {lab=#net91}
N 400 750 400 1050 {lab=#net91}
N 400 1050 400 1140 {lab=#net91}
N 2170 980 2230 980 {lab=#net92}
N 2170 980 2170 1080 {lab=#net92}
N 2920 1210 2980 1210 {lab=#net92}
N 2920 1080 2920 1210 {lab=#net92}
N 2460 1210 2520 1210 {lab=#net92}
N 2460 1080 2460 1210 {lab=#net92}
N 1830 930 1910 930 {lab=#net92}
N 1910 930 1910 1080 {lab=#net92}
N 1910 1080 2170 1080 {lab=#net92}
N 2170 1080 2460 1080 {lab=#net92}
N 2460 1080 2920 1080 {lab=#net92}
N 2200 380 2230 380 {lab=#net93}
N 2200 380 2200 480 {lab=#net93}
N 390 480 2200 480 {lab=#net93}
N 1980 690 2040 690 {lab=#net93}
N 1980 600 1980 690 {lab=#net93}
N 390 600 1980 600 {lab=#net93}
N 2680 980 2720 980 {lab=#net93}
N 2680 870 2680 980 {lab=#net93}
N 1830 970 1920 970 {lab=#net93}
N 1920 870 1920 970 {lab=#net93}
N 390 870 1920 870 {lab=#net93}
N 1920 870 2680 870 {lab=#net93}
N 390 1310 3330 1310 {lab=#net93}
N 2700 1490 2720 1490 {lab=#net93}
N 2700 1490 2700 1630 {lab=#net93}
N 390 1630 2700 1630 {lab=#net93}
N 390 480 390 600 {lab=#net93}
N 390 600 390 870 {lab=#net93}
N 390 870 390 1310 {lab=#net93}
N 390 1310 390 1630 {lab=#net93}
N 4560 1560 4560 1580 {lab=#net94}
N 4560 1580 4720 1580 {lab=#net94}
N 4720 1370 4720 1580 {lab=#net94}
N 1990 1200 2040 1200 {lab=#net94}
N 1990 1200 1990 1370 {lab=#net94}
N 2450 1230 2520 1230 {lab=#net94}
N 2450 1230 2450 1370 {lab=#net94}
N 1630 1190 1710 1190 {lab=#net94}
N 1710 1190 1710 1370 {lab=#net94}
N 1710 1370 1990 1370 {lab=#net94}
N 1990 1370 2450 1370 {lab=#net94}
N 2450 1370 3570 1370 {lab=#net94}
N 3570 1370 4720 1370 {lab=#net94}
N 1630 1230 1720 1230 {lab=#net95}
N 1720 1130 1720 1230 {lab=#net95}
N 1720 1130 2910 1130 {lab=#net95}
N 4090 1560 4090 1580 {lab=#net96}
N 4090 1580 4230 1580 {lab=#net96}
N 4230 1380 4230 1580 {lab=#net96}
N 3560 1520 3590 1520 {lab=#net96}
N 3560 1380 3560 1520 {lab=#net96}
N 4260 1200 4310 1200 {lab=#net96}
N 4260 1200 4260 1380 {lab=#net96}
N 520 1490 590 1490 {lab=#net96}
N 590 1380 590 1490 {lab=#net96}
N 590 1380 3560 1380 {lab=#net96}
N 3560 1380 4230 1380 {lab=#net96}
N 4230 1380 4260 1380 {lab=#net96}
N 4960 1540 4990 1540 {lab=#net97}
N 4960 1390 4960 1540 {lab=#net97}
N 2910 1250 2980 1250 {lab=#net95}
N 2440 1250 2520 1250 {lab=#net97}
N 2440 1250 2440 1390 {lab=#net97}
N 520 1530 600 1530 {lab=#net97}
N 600 1390 600 1530 {lab=#net97}
N 600 1390 2440 1390 {lab=#net97}
N 2440 1390 2910 1390 {lab=#net97}
N 2910 1390 4960 1390 {lab=#net97}
N 3890 1260 3890 1280 {lab=#net98}
N 3890 1280 4010 1280 {lab=#net98}
N 4010 1280 4010 1310 {lab=#net98}
N 4010 1310 6580 1310 {lab=#net98}
N 2690 1510 2720 1510 {lab=#net98}
N 2690 1420 2690 1510 {lab=#net98}
N 6390 1560 6390 1580 {lab=#net98}
N 6390 1580 6530 1580 {lab=#net98}
N 6530 1420 6530 1580 {lab=#net98}
N 5930 1560 5930 1580 {lab=#net98}
N 5930 1580 6070 1580 {lab=#net98}
N 6070 1420 6070 1580 {lab=#net98}
N 1750 1420 2220 1420 {lab=#net98}
N 2220 1420 2690 1420 {lab=#net98}
N 2690 1420 3150 1420 {lab=#net98}
N 3150 1420 3550 1420 {lab=#net98}
N 3550 1420 6070 1420 {lab=#net98}
N 6070 1420 6530 1420 {lab=#net98}
N 6530 1420 6580 1420 {lab=#net98}
N 3800 1780 3850 1780 {lab=#net99}
N 3800 1900 6580 1900 {lab=#net98}
N 3250 2440 3250 2460 {lab=#net98}
N 3250 2460 3330 2460 {lab=#net98}
N 3330 2320 3330 2460 {lab=#net98}
N 2230 2320 3330 2320 {lab=#net98}
N 3330 2320 6580 2320 {lab=#net98}
N 2900 2750 2930 2750 {lab=#net98}
N 2900 2580 2900 2750 {lab=#net98}
N 6080 2710 6110 2710 {lab=#net98}
N 6080 2580 6080 2710 {lab=#net98}
N 1180 2700 1230 2700 {lab=#net98}
N 1230 2580 1230 2700 {lab=#net98}
N 1230 2580 2900 2580 {lab=#net98}
N 2900 2580 6080 2580 {lab=#net98}
N 6080 2580 6580 2580 {lab=#net98}
N 6580 1310 6580 1420 {lab=#net98}
N 6580 1420 6580 1900 {lab=#net98}
N 6580 1900 6580 2320 {lab=#net98}
N 6580 2320 6580 2580 {lab=#net98}
N 1180 2740 1230 2740 {lab=#net100}
N 2680 1530 2720 1530 {lab=#net99}
N 2680 1530 2680 1640 {lab=#net99}
N 1750 1510 1780 1510 {lab=#net98}
N 390 1640 1750 1640 {lab=#net99}
N 1750 1640 2210 1640 {lab=#net99}
N 2210 1640 2680 1640 {lab=#net99}
N 2680 1640 3150 1640 {lab=#net99}
N 3790 1800 3850 1800 {lab=#net98}
N 390 1710 3790 1710 {lab=#net99}
N 520 2070 590 2070 {lab=#net99}
N 590 2070 590 2180 {lab=#net99}
N 390 2180 590 2180 {lab=#net99}
N 2230 2400 2280 2400 {lab=#net99}
N 2230 2400 2230 2480 {lab=#net99}
N 390 2480 2230 2480 {lab=#net99}
N 4650 2750 4740 2750 {lab=#net99}
N 4650 2570 4650 2750 {lab=#net99}
N 6070 2750 6110 2750 {lab=#net99}
N 6070 2570 6070 2750 {lab=#net99}
N 390 2570 4650 2570 {lab=#net99}
N 4650 2570 6070 2570 {lab=#net99}
N 390 1640 390 1710 {lab=#net99}
N 390 1710 390 2180 {lab=#net99}
N 390 2180 390 2480 {lab=#net99}
N 390 2480 390 2570 {lab=#net99}
N 4730 1820 4790 1820 {lab=#net101}
N 4730 1820 4730 1950 {lab=#net101}
N 520 2110 600 2110 {lab=#net101}
N 600 1950 600 2110 {lab=#net101}
N 600 1950 4730 1950 {lab=#net101}
N 2670 1550 2720 1550 {lab=#net102}
N 2670 1410 2670 1550 {lab=#net102}
N 1740 1530 1780 1530 {lab=#net102}
N 1740 1410 1740 1530 {lab=#net102}
N 3140 1530 3160 1530 {lab=#net102}
N 3140 1410 3140 1530 {lab=#net102}
N 2200 1530 2230 1530 {lab=#net102}
N 2200 1410 2200 1530 {lab=#net102}
N 380 1410 1740 1410 {lab=#net102}
N 1740 1410 2200 1410 {lab=#net102}
N 2200 1410 2670 1410 {lab=#net102}
N 2670 1410 3140 1410 {lab=#net102}
N 3780 1820 3850 1820 {lab=#net102}
N 3780 1820 3780 1910 {lab=#net102}
N 4350 1840 4350 1860 {lab=#net102}
N 4350 1860 4470 1860 {lab=#net102}
N 4470 1860 4470 1910 {lab=#net102}
N 380 1910 3780 1910 {lab=#net102}
N 3780 1910 4470 1910 {lab=#net102}
N 2220 2380 2280 2380 {lab=#net102}
N 380 2320 2220 2320 {lab=#net102}
N 5170 2750 5200 2750 {lab=#net102}
N 5170 2560 5170 2750 {lab=#net102}
N 730 2700 780 2700 {lab=#net102}
N 780 2560 780 2700 {lab=#net102}
N 380 2560 780 2560 {lab=#net102}
N 780 2560 5170 2560 {lab=#net102}
N 380 1410 380 1910 {lab=#net102}
N 380 1910 380 2320 {lab=#net102}
N 380 2320 380 2560 {lab=#net102}
N 730 2740 780 2740 {lab=#net103}
N 3290 2100 3310 2100 {lab=#net104}
N 3310 2100 3310 2290 {lab=#net104}
N 6370 2140 6370 2160 {lab=#net104}
N 6370 2160 6490 2160 {lab=#net104}
N 6490 2160 6490 2290 {lab=#net104}
N 1410 2440 1410 2460 {lab=#net104}
N 1410 2460 1490 2460 {lab=#net104}
N 1490 2290 1490 2460 {lab=#net104}
N 1830 2440 1830 2460 {lab=#net104}
N 1830 2460 1950 2460 {lab=#net104}
N 1950 2290 1950 2460 {lab=#net104}
N 5470 2140 5470 2160 {lab=#net104}
N 5470 2160 5600 2160 {lab=#net104}
N 5600 2160 5600 2290 {lab=#net104}
N 3610 2140 3610 2160 {lab=#net104}
N 3610 2160 3750 2160 {lab=#net104}
N 3750 2160 3750 2290 {lab=#net104}
N 1490 2290 1950 2290 {lab=#net104}
N 1950 2290 3310 2290 {lab=#net104}
N 3310 2290 3750 2290 {lab=#net104}
N 3750 2290 5600 2290 {lab=#net104}
N 5600 2290 6490 2290 {lab=#net104}
N 1600 1260 1600 1280 {lab=reset}
N 1600 1280 1730 1280 {lab=reset}
N 1730 1120 1730 1280 {lab=reset}
N 1200 1260 1200 1280 {lab=reset}
N 1200 1280 1330 1280 {lab=reset}
N 1330 1120 1330 1280 {lab=reset}
N 750 1260 750 1280 {lab=reset}
N 750 1280 870 1280 {lab=reset}
N 870 1120 870 1280 {lab=reset}
N 5740 1260 5740 1280 {lab=reset}
N 5740 1280 5870 1280 {lab=reset}
N 5870 1120 5870 1280 {lab=reset}
N 4810 1260 4810 1280 {lab=reset}
N 4810 1280 4950 1280 {lab=reset}
N 4950 1120 4950 1280 {lab=reset}
N 370 1120 870 1120 {lab=reset}
N 870 1120 1330 1120 {lab=reset}
N 1330 1120 1730 1120 {lab=reset}
N 1730 1120 4950 1120 {lab=reset}
N 4950 1120 5870 1120 {lab=reset}
N 490 1560 490 1580 {lab=reset}
N 490 1580 610 1580 {lab=reset}
N 610 1580 610 1650 {lab=reset}
N 940 1560 940 1580 {lab=reset}
N 940 1580 1060 1580 {lab=reset}
N 1060 1580 1060 1650 {lab=reset}
N 300 1490 310 1490 {lab=reset}
N 310 1490 310 1650 {lab=reset}
N 310 1650 370 1650 {lab=reset}
N 370 1650 610 1650 {lab=reset}
N 610 1650 1060 1650 {lab=reset}
N 1100 1780 1180 1780 {lab=reset}
N 1100 1700 1100 1780 {lab=reset}
N 5270 1840 5270 1860 {lab=reset}
N 5270 1860 5400 1860 {lab=reset}
N 5400 1700 5400 1860 {lab=reset}
N 370 1700 1100 1700 {lab=reset}
N 1100 1700 1500 1700 {lab=reset}
N 1500 1700 5400 1700 {lab=reset}
N 370 1120 370 1650 {lab=reset}
N 370 1650 370 1700 {lab=reset}
N 2650 1800 2680 1800 {lab=#net105}
N 2680 1800 2680 1960 {lab=#net105}
N 2680 2120 2720 2120 {lab=#net105}
N 2680 1960 2680 2120 {lab=#net105}
N 6480 360 6530 360 {lab=#net106}
N 6530 360 6530 480 {lab=#net106}
N 6530 480 6600 480 {lab=#net106}
N 2200 2120 2230 2120 {lab=#net106}
N 2200 2020 2200 2120 {lab=#net106}
N 2200 2020 6600 2020 {lab=#net106}
N 6600 480 6600 2020 {lab=#net106}
N 4740 680 4780 680 {lab=#net107}
N 4740 680 4740 800 {lab=#net107}
N 4020 970 4040 970 {lab=#net107}
N 4020 800 4020 970 {lab=#net107}
N 2930 680 2970 680 {lab=#net107}
N 2930 680 2930 800 {lab=#net107}
N 6470 960 6530 960 {lab=#net107}
N 6530 800 6530 960 {lab=#net107}
N 2930 800 4020 800 {lab=#net107}
N 4020 800 4740 800 {lab=#net107}
N 4740 800 6530 800 {lab=#net107}
N 6310 960 6350 960 {lab=#net108}
N 6310 960 6310 1050 {lab=#net108}
N 6310 1050 6620 1050 {lab=#net108}
N 1050 2100 1100 2100 {lab=#net108}
N 1100 2100 1100 2180 {lab=#net108}
N 1100 2180 6620 2180 {lab=#net108}
N 6620 1050 6620 2180 {lab=#net108}
N 6020 960 6080 960 {lab=#net109}
N 6080 960 6080 1080 {lab=#net109}
N 4250 1240 4310 1240 {lab=#net109}
N 4250 1080 4250 1240 {lab=#net109}
N 6100 1240 6160 1240 {lab=#net109}
N 6100 1080 6100 1240 {lab=#net109}
N 5190 1240 5250 1240 {lab=#net109}
N 5190 1080 5190 1240 {lab=#net109}
N 4250 1080 5190 1080 {lab=#net109}
N 5190 1080 6080 1080 {lab=#net109}
N 6080 1080 6100 1080 {lab=#net109}
N 5660 670 5720 670 {lab=#net110}
N 5660 670 5660 750 {lab=#net110}
N 5190 670 5250 670 {lab=#net110}
N 5190 670 5190 750 {lab=#net110}
N 4840 640 4870 640 {lab=#net110}
N 4870 640 4870 750 {lab=#net110}
N 4870 750 5190 750 {lab=#net110}
N 5190 750 5660 750 {lab=#net110}
N 4490 930 4520 930 {lab=#net111}
N 4490 810 4490 930 {lab=#net111}
N 5430 940 5450 940 {lab=#net111}
N 5430 810 5430 940 {lab=#net111}
N 4970 980 4990 980 {lab=#net111}
N 3800 650 3850 650 {lab=#net111}
N 3800 650 3800 810 {lab=#net111}
N 3530 960 3590 960 {lab=#net111}
N 3350 650 3400 650 {lab=#net111}
N 3350 650 3350 810 {lab=#net111}
N 4840 680 4940 680 {lab=#net111}
N 4940 680 4940 810 {lab=#net111}
N 3350 810 3530 810 {lab=#net111}
N 3530 810 3800 810 {lab=#net111}
N 3800 810 4490 810 {lab=#net111}
N 4490 810 4940 810 {lab=#net111}
N 4940 810 4970 810 {lab=#net111}
N 4970 810 5430 810 {lab=#net111}
N 5430 810 6100 810 {lab=#net111}
N 5410 980 5450 980 {lab=#net112}
N 5410 820 5410 980 {lab=#net112}
N 5180 690 5250 690 {lab=#net112}
N 5180 690 5180 820 {lab=#net112}
N 2460 670 2520 670 {lab=#net112}
N 2460 670 2460 820 {lab=#net112}
N 4100 930 4180 930 {lab=#net112}
N 4180 820 4180 930 {lab=#net112}
N 2460 820 4180 820 {lab=#net112}
N 4180 820 5180 820 {lab=#net112}
N 5180 820 5410 820 {lab=#net112}
N 4480 950 4520 950 {lab=#net113}
N 4480 830 4480 950 {lab=#net113}
N 6090 680 6160 680 {lab=#net113}
N 6090 680 6090 830 {lab=#net113}
N 5670 650 5720 650 {lab=#net113}
N 5670 650 5670 830 {lab=#net113}
N 4960 960 4990 960 {lab=#net113}
N 4960 830 4960 960 {lab=#net113}
N 4260 650 4310 650 {lab=#net113}
N 4260 650 4260 830 {lab=#net113}
N 4100 970 4190 970 {lab=#net113}
N 4190 830 4190 970 {lab=#net113}
N 3150 830 4190 830 {lab=#net113}
N 4190 830 4260 830 {lab=#net113}
N 4260 830 4480 830 {lab=#net113}
N 4480 830 4960 830 {lab=#net113}
N 4960 830 5670 830 {lab=#net113}
N 5670 830 6090 830 {lab=#net113}
N 5650 690 5720 690 {lab=#net114}
N 5650 590 5650 690 {lab=#net114}
N 3780 690 3850 690 {lab=#net114}
N 3780 590 3780 690 {lab=#net114}
N 670 650 730 650 {lab=#net114}
N 670 590 670 650 {lab=#net114}
N 2450 690 2520 690 {lab=#net114}
N 2450 590 2450 690 {lab=#net114}
N 3030 680 3120 680 {lab=#net114}
N 3120 590 3120 680 {lab=#net114}
N 670 590 2450 590 {lab=#net114}
N 2450 590 3120 590 {lab=#net114}
N 3120 590 3780 590 {lab=#net114}
N 3780 590 5650 590 {lab=#net114}
N 4470 990 4520 990 {lab=#net115}
N 6080 700 6160 700 {lab=#net115}
N 6080 700 6080 840 {lab=#net115}
N 5420 960 5450 960 {lab=#net115}
N 5420 840 5420 960 {lab=#net115}
N 4950 940 4990 940 {lab=#net115}
N 4250 670 4310 670 {lab=#net115}
N 4250 670 4250 840 {lab=#net115}
N 5200 650 5250 650 {lab=#net115}
N 5200 650 5200 840 {lab=#net115}
N 3340 670 3400 670 {lab=#net115}
N 3340 670 3340 840 {lab=#net115}
N 3030 640 3110 640 {lab=#net115}
N 3110 640 3110 840 {lab=#net115}
N 3110 840 3340 840 {lab=#net115}
N 3340 840 4250 840 {lab=#net115}
N 4250 840 4470 840 {lab=#net115}
N 4470 840 4950 840 {lab=#net115}
N 4950 840 5200 840 {lab=#net115}
N 5200 840 5420 840 {lab=#net115}
N 5420 840 6080 840 {lab=#net115}
N 880 2110 920 2110 {lab=#net116}
N 880 2110 880 2300 {lab=#net116}
N 2690 2430 2770 2430 {lab=#net116}
N 2690 2300 2690 2430 {lab=#net116}
N 1470 2100 1500 2100 {lab=#net116}
N 1500 2100 1500 2300 {lab=#net116}
N 880 2300 1500 2300 {lab=#net116}
N 1500 2300 1710 2300 {lab=#net116}
N 1710 2300 2690 2300 {lab=#net116}
N 1310 2120 1340 2120 {lab=#net117}
N 1310 2020 1310 2120 {lab=#net117}
N 1910 2100 1950 2100 {lab=#net117}
N 1950 2020 1950 2100 {lab=#net117}
N 1310 2020 1950 2020 {lab=#net117}
N 1110 680 1170 680 {lab=scl}
N 1110 680 1110 760 {lab=scl}
N 360 760 1110 760 {lab=scl}
N 440 960 470 960 {lab=scl}
N 440 860 440 960 {lab=scl}
N 1760 970 1770 970 {lab=scl}
N 1760 860 1760 970 {lab=scl}
N 360 860 440 860 {lab=scl}
N 440 860 1760 860 {lab=scl}
N 1530 1230 1570 1230 {lab=scl}
N 1530 1230 1530 1320 {lab=scl}
N 1110 1230 1170 1230 {lab=scl}
N 1110 1230 1110 1320 {lab=scl}
N 670 1230 720 1230 {lab=scl}
N 670 1230 670 1320 {lab=scl}
N 5670 1230 5710 1230 {lab=scl}
N 5670 1230 5670 1320 {lab=scl}
N 4740 1230 4780 1230 {lab=scl}
N 4740 1230 4740 1320 {lab=scl}
N 360 1320 670 1320 {lab=scl}
N 670 1320 1110 1320 {lab=scl}
N 1110 1320 1530 1320 {lab=scl}
N 1530 1320 4740 1320 {lab=scl}
N 4740 1320 5670 1320 {lab=scl}
N 450 1530 460 1530 {lab=scl}
N 450 1400 450 1530 {lab=scl}
N 900 1530 910 1530 {lab=scl}
N 900 1400 900 1530 {lab=scl}
N 300 1540 320 1540 {lab=scl}
N 320 1400 320 1540 {lab=scl}
N 320 1400 360 1400 {lab=scl}
N 360 1400 450 1400 {lab=scl}
N 450 1400 900 1400 {lab=scl}
N 5200 1810 5240 1810 {lab=scl}
N 5200 1810 5200 1920 {lab=scl}
N 670 1800 730 1800 {lab=scl}
N 670 1800 670 1920 {lab=scl}
N 360 1920 670 1920 {lab=scl}
N 670 1920 5200 1920 {lab=scl}
N 870 2130 920 2130 {lab=scl}
N 870 2130 870 2190 {lab=scl}
N 450 2110 460 2110 {lab=scl}
N 450 2110 450 2190 {lab=scl}
N 360 2190 450 2190 {lab=scl}
N 450 2190 870 2190 {lab=scl}
N 440 2380 520 2380 {lab=scl}
N 440 2380 440 2490 {lab=scl}
N 1340 2410 1380 2410 {lab=scl}
N 1340 2410 1340 2490 {lab=scl}
N 1760 2410 1800 2410 {lab=scl}
N 1760 2410 1760 2490 {lab=scl}
N 360 2490 440 2490 {lab=scl}
N 440 2490 1340 2490 {lab=scl}
N 1340 2490 1760 2490 {lab=scl}
N 1110 2740 1120 2740 {lab=scl}
N 1110 2550 1110 2740 {lab=scl}
N 660 2740 670 2740 {lab=scl}
N 660 2550 660 2740 {lab=scl}
N 360 2550 660 2550 {lab=scl}
N 660 2550 1110 2550 {lab=scl}
N 360 760 360 860 {lab=scl}
N 360 860 360 1320 {lab=scl}
N 360 1320 360 1400 {lab=scl}
N 360 1400 360 1920 {lab=scl}
N 360 1920 360 2190 {lab=scl}
N 360 2190 360 2490 {lab=scl}
N 360 2490 360 2550 {lab=scl}
N 1960 1800 2040 1800 {lab=#net118}
N 1960 1800 1960 1970 {lab=#net118}
N 6310 2110 6340 2110 {lab=#net118}
N 6310 1970 6310 2110 {lab=#net118}
N 5430 2110 5440 2110 {lab=#net118}
N 5430 1970 5430 2110 {lab=#net118}
N 3570 2110 3580 2110 {lab=#net118}
N 3570 1970 3570 2110 {lab=#net118}
N 850 1800 870 1800 {lab=#net118}
N 870 1800 870 1970 {lab=#net118}
N 870 1970 1960 1970 {lab=#net118}
N 1960 1970 3330 1970 {lab=#net118}
N 3330 1970 3570 1970 {lab=#net118}
N 3570 1970 5430 1970 {lab=#net118}
N 5430 1970 6310 1970 {lab=#net118}
N 6310 2430 6400 2430 {lab=sda_drive_low}
N 6310 2300 6310 2430 {lab=sda_drive_low}
N 6400 2070 6480 2070 {lab=sda_drive_low}
N 6480 2070 6480 2300 {lab=sda_drive_low}
N 6570 2100 6650 2100 {lab=sda_drive_low}
N 6570 2100 6570 2300 {lab=sda_drive_low}
N 6310 2300 6480 2300 {lab=sda_drive_low}
N 6480 2300 6570 2300 {lab=sda_drive_low}
N 440 360 470 360 {lab=sda_in}
N 440 360 440 490 {lab=sda_in}
N 1330 380 1340 380 {lab=sda_in}
N 1330 380 1330 490 {lab=sda_in}
N 900 360 920 360 {lab=sda_in}
N 900 360 900 490 {lab=sda_in}
N 350 490 440 490 {lab=sda_in}
N 440 490 900 490 {lab=sda_in}
N 900 490 1330 490 {lab=sda_in}
N 660 690 730 690 {lab=sda_in}
N 660 590 660 690 {lab=sda_in}
N 350 590 660 590 {lab=sda_in}
N 300 1000 320 1000 {lab=sda_in}
N 320 1000 320 1060 {lab=sda_in}
N 320 1060 350 1060 {lab=sda_in}
N 350 1060 3150 1060 {lab=sda_in}
N 1980 1240 2040 1240 {lab=sda_in}
N 1980 1110 1980 1240 {lab=sda_in}
N 350 1110 1980 1110 {lab=sda_in}
N 5420 1540 5450 1540 {lab=sda_in}
N 5420 1540 5420 1660 {lab=sda_in}
N 1330 1540 1340 1540 {lab=sda_in}
N 1330 1540 1330 1660 {lab=sda_in}
N 350 1660 1330 1660 {lab=sda_in}
N 1330 1660 5420 1660 {lab=sda_in}
N 2470 1780 2520 1780 {lab=sda_in}
N 2470 1690 2470 1780 {lab=sda_in}
N 1950 1820 2040 1820 {lab=sda_in}
N 1950 1690 1950 1820 {lab=sda_in}
N 350 1690 1950 1690 {lab=sda_in}
N 1950 1690 2470 1690 {lab=sda_in}
N 350 490 350 590 {lab=sda_in}
N 350 590 350 1060 {lab=sda_in}
N 350 1060 350 1110 {lab=sda_in}
N 350 1110 350 1660 {lab=sda_in}
N 350 1660 350 1690 {lab=sda_in}
N 590 360 650 360 {lab=#net119}
N 650 360 650 500 {lab=#net119}
N 5880 380 5890 380 {lab=#net119}
N 5880 380 5880 500 {lab=#net119}
N 340 500 650 500 {lab=#net119}
N 650 500 5880 500 {lab=#net119}
N 3790 670 3850 670 {lab=#net119}
N 3790 670 3790 770 {lab=#net119}
N 4240 690 4310 690 {lab=#net119}
N 4240 690 4240 770 {lab=#net119}
N 3330 690 3400 690 {lab=#net119}
N 3330 690 3330 770 {lab=#net119}
N 2470 650 2520 650 {lab=#net119}
N 2470 650 2470 770 {lab=#net119}
N 340 770 2470 770 {lab=#net119}
N 2470 770 3330 770 {lab=#net119}
N 3330 770 3790 770 {lab=#net119}
N 3790 770 4240 770 {lab=#net119}
N 3320 1820 3400 1820 {lab=#net119}
N 3320 1820 3320 1930 {lab=#net119}
N 340 1930 3320 1930 {lab=#net119}
N 430 2400 520 2400 {lab=#net119}
N 430 2310 430 2400 {lab=#net119}
N 340 2310 430 2310 {lab=#net119}
N 340 500 340 770 {lab=#net119}
N 340 770 340 1930 {lab=#net119}
N 340 1930 340 2310 {lab=#net119}
N 6070 2400 6080 2400 {lab=#net120}
N 6080 2300 6080 2400 {lab=#net120}
N 6300 2070 6340 2070 {lab=#net120}
N 6300 2070 6300 2300 {lab=#net120}
N 6080 2300 6300 2300 {lab=#net120}
N 6400 2110 6470 2110 {lab=#net121}
N 4230 2400 4240 2400 {lab=#net122}
N 4240 2400 4240 2510 {lab=#net122}
N 3300 2750 3350 2750 {lab=#net122}
N 3300 2510 3300 2750 {lab=#net122}
N 3160 2380 3210 2380 {lab=#net122}
N 3160 2380 3160 2510 {lab=#net122}
N 3160 2510 3300 2510 {lab=#net122}
N 3300 2510 4240 2510 {lab=#net122}
N 5170 2400 5180 2400 {lab=#net123}
N 5180 2400 5180 2520 {lab=#net123}
N 2440 2710 2470 2710 {lab=#net123}
N 2440 2520 2440 2710 {lab=#net123}
N 4240 2710 4260 2710 {lab=#net123}
N 4240 2520 4240 2710 {lab=#net123}
N 3780 2710 3800 2710 {lab=#net123}
N 3780 2520 3780 2710 {lab=#net123}
N 2440 2520 3780 2520 {lab=#net123}
N 3780 2520 4240 2520 {lab=#net123}
N 4240 2520 5180 2520 {lab=#net123}
N 4720 2400 4730 2400 {lab=#net124}
N 4730 2400 4730 2530 {lab=#net124}
N 430 2420 520 2420 {lab=#net124}
N 430 2420 430 2530 {lab=#net124}
N 1510 2750 1530 2750 {lab=#net124}
N 1510 2530 1510 2750 {lab=#net124}
N 900 2420 970 2420 {lab=#net124}
N 900 2420 900 2530 {lab=#net124}
N 1970 2750 1990 2750 {lab=#net124}
N 1970 2530 1970 2750 {lab=#net124}
N 430 2530 900 2530 {lab=#net124}
N 900 2530 1510 2530 {lab=#net124}
N 1510 2530 1970 2530 {lab=#net124}
N 1970 2530 4730 2530 {lab=#net124}
N 1710 1800 1740 1800 {lab=#net125}
N 1740 1800 1740 1980 {lab=#net125}
N 1330 2080 1340 2080 {lab=#net126}
N 1330 1980 1740 1980 {lab=#net125}
N 650 2310 650 2400 {lab=#net126}
N 1320 2100 1340 2100 {lab=#net125}
N 650 2310 1320 2310 {lab=#net126}
N 3800 1200 3850 1200 {lab=#net127}
N 3800 1090 3800 1200 {lab=#net127}
N 1310 940 1340 940 {lab=#net127}
N 1310 940 1310 1090 {lab=#net127}
N 1230 1190 1310 1190 {lab=#net127}
N 1310 1090 1310 1190 {lab=#net127}
N 1310 1090 3800 1090 {lab=#net127}
N 1230 1230 1310 1230 {lab=#net128}
N 3790 1240 3850 1240 {lab=#net129}
N 3790 1100 3790 1240 {lab=#net129}
N 900 940 920 940 {lab=#net129}
N 900 940 900 1100 {lab=#net129}
N 780 1190 860 1190 {lab=#net129}
N 860 1100 860 1190 {lab=#net129}
N 860 1100 900 1100 {lab=#net129}
N 900 1100 3790 1100 {lab=#net129}
N 780 1230 850 1230 {lab=#net130}
N 2170 1800 2200 1800 {lab=#net131}
N 2200 1800 2200 1990 {lab=#net131}
N 1100 1820 1180 1820 {lab=#net131}
N 1100 1820 1100 1990 {lab=#net131}
N 1730 2080 1780 2080 {lab=#net116}
N 1100 1990 1730 1990 {lab=#net131}
N 1730 1990 2200 1990 {lab=#net131}
N 1200 710 1200 730 {lab=#net132}
N 1200 730 1330 730 {lab=#net132}
N 1330 580 1330 730 {lab=#net132}
N 4810 710 4810 730 {lab=#net132}
N 4810 730 4950 730 {lab=#net132}
N 4950 580 4950 730 {lab=#net132}
N 3000 710 3000 730 {lab=#net132}
N 3000 730 3130 730 {lab=#net132}
N 3130 580 3130 730 {lab=#net132}
N 330 580 1330 580 {lab=#net132}
N 1330 580 3130 580 {lab=#net132}
N 3130 580 4950 580 {lab=#net132}
N 1800 1000 1800 1020 {lab=#net132}
N 1800 1020 1930 1020 {lab=#net132}
N 1930 850 1930 1020 {lab=#net132}
N 4070 1000 4070 1020 {lab=#net132}
N 4070 1020 4200 1020 {lab=#net132}
N 4200 850 4200 1020 {lab=#net132}
N 330 850 1930 850 {lab=#net132}
N 1930 850 4200 850 {lab=#net132}
N 1310 1800 1330 1800 {lab=#net132}
N 1330 1680 1330 1800 {lab=#net132}
N 330 1680 1330 1680 {lab=#net132}
N 3130 2080 3160 2080 {lab=#net132}
N 3130 2010 3130 2080 {lab=#net132}
N 490 2140 490 2160 {lab=#net132}
N 490 2160 610 2160 {lab=#net132}
N 610 2010 610 2160 {lab=#net132}
N 330 2010 610 2010 {lab=#net132}
N 610 2010 3130 2010 {lab=#net132}
N 1150 2770 1150 2790 {lab=#net132}
N 1150 2790 1240 2790 {lab=#net132}
N 1240 2540 1240 2790 {lab=#net132}
N 700 2770 700 2790 {lab=#net132}
N 700 2790 790 2790 {lab=#net132}
N 790 2540 790 2790 {lab=#net132}
N 330 2540 790 2540 {lab=#net132}
N 790 2540 1240 2540 {lab=#net132}
N 330 580 330 850 {lab=#net132}
N 330 850 330 1680 {lab=#net132}
N 330 1680 330 2010 {lab=#net132}
N 330 2010 330 2540 {lab=#net132}
N 3530 1800 3550 1800 {lab=#net133}
N 3550 1800 3550 2000 {lab=#net133}
N 3110 2120 3160 2120 {lab=#net133}
N 3110 2000 3110 2120 {lab=#net133}
N 1500 2000 3110 2000 {lab=#net133}
N 3110 2000 3550 2000 {lab=#net133}
N 4400 1800 4460 1800 {lab=#net134}
N 4460 1800 4460 2000 {lab=#net134}
N 4470 2120 4520 2120 {lab=#net134}
N 4470 2000 4470 2120 {lab=#net134}
N 4460 2000 4470 2000 {lab=#net134}
N 3150 940 3160 940 {lab=sda_in}
N 3150 940 3150 1060 {lab=sda_in}
N 3140 830 3150 830 {lab=#net113}
N 3140 830 3140 980 {lab=#net113}
N 3140 980 3160 980 {lab=#net113}
N 6100 640 6160 640 {lab=#net111}
N 6100 640 6100 810 {lab=#net111}
N 6140 660 6160 660 {lab=#net13}
N 6140 600 6140 660 {lab=#net13}
N 6140 600 6560 600 {lab=#net13}
N 2910 1130 2910 1250 {lab=#net95}
N 2900 1230 2980 1230 {lab=#net97}
N 2900 1230 2900 1390 {lab=#net97}
N 3330 1250 3400 1250 {lab=#net91}
N 3330 1310 3340 1310 {lab=#net93}
N 3340 1230 3340 1310 {lab=#net93}
N 3340 1230 3400 1230 {lab=#net93}
N 3330 1140 3330 1250 {lab=#net91}
N 1720 1490 1720 1640 {lab=#net99}
N 1720 1490 1780 1490 {lab=#net99}
N 1750 1420 1750 1510 {lab=#net98}
N 2180 1420 2180 1510 {lab=#net98}
N 2170 1490 2170 1640 {lab=#net99}
N 2180 1510 2230 1510 {lab=#net98}
N 2170 1490 2230 1490 {lab=#net99}
N 3120 1420 3120 1510 {lab=#net98}
N 3110 1490 3110 1640 {lab=#net99}
N 3110 1490 3160 1490 {lab=#net99}
N 3120 1510 3160 1510 {lab=#net98}
N 3530 1540 3590 1540 {lab=#net98}
N 3540 1500 3590 1500 {lab=#net94}
N 3340 1780 3340 1970 {lab=#net118}
N 3340 1780 3400 1780 {lab=#net118}
N 1740 1990 1740 2120 {lab=#net131}
N 1740 2120 1780 2120 {lab=#net131}
N 1730 2080 1730 2300 {lab=#net116}
N 1330 2080 1330 2310 {lab=#net126}
N 1320 2310 1330 2310 {lab=#net126}
N 1320 1980 1320 2100 {lab=#net125}
N 1320 1980 1330 1980 {lab=#net125}
N 3330 1800 3400 1800 {lab=#net12}
N 3330 1730 3330 1800 {lab=#net12}
N 3800 1710 3800 1780 {lab=#net99}
N 3790 1710 3800 1710 {lab=#net99}
N 3790 1800 3790 1900 {lab=#net98}
N 3790 1900 3800 1900 {lab=#net98}
N 4470 840 4470 990 {lab=#net115}
N 4460 970 4460 1050 {lab=#net91}
N 900 2090 900 2230 {lab=#net6}
N 890 2070 890 2250 {lab=#net8}
N 4450 380 4450 540 {lab=#net80}
N 4440 360 4440 550 {lab=#net81}
N 3530 810 3530 960 {lab=#net111}
N 3540 790 3540 980 {lab=#net84}
N 1490 1700 1490 1820 {lab=reset}
N 1480 1800 1480 2000 {lab=#net133}
N 1480 2000 1500 2000 {lab=#net133}
N 1480 1800 1580 1800 {lab=#net133}
N 1490 1820 1580 1820 {lab=reset}
N 3990 1940 3990 2120 {lab=#net44}
N 3980 2030 3980 2100 {lab=#net45}
N 5870 2330 5870 2370 {lab=#net32}
N 5880 2260 5880 2390 {lab=#net31}
N 4950 840 4950 940 {lab=#net115}
N 4970 810 4970 980 {lab=#net111}
N 3540 1370 3540 1500 {lab=#net94}
N 3530 1420 3530 1540 {lab=#net98}
N 2240 2420 2280 2420 {lab=#net98}
N 2240 2320 2240 2420 {lab=#net98}
N 2220 2320 2220 2380 {lab=#net102}
C {TR-1um_5_stdcell/INV_X1.sym} 490 360 0 0 {name=xgbl_011_inv_x1}
C {TR-1um_5_stdcell/DEL4.sym} 940 360 0 0 {name=xgbl_prim_000_delay_element}
C {TR-1um_5_stdcell/AND2_X1.sym} 1360 360 0 0 {name=xgbl_090_and2_x1}
C {TR-1um_5_stdcell/XOR2.sym} 1800 360 0 0 {name=xgbl_043_xor2}
C {TR-1um_5_stdcell/AND3_X1.sym} 2250 360 0 0 {name=xgbl_054_and3_x1}
C {TR-1um_5_stdcell/NOR3.sym} 2740 360 0 0 {name=xgbl_092_nor3}
C {TR-1um_5_stdcell/DEL4.sym} 3180 360 0 0 {name=xgbl_prim_001_delay_element}
C {TR-1um_5_stdcell/DEL4.sym} 3610 360 0 0 {name=xgbl_prim_002_delay_element}
C {TR-1um_5_stdcell/DEL4.sym} 4070 360 0 0 {name=xgbl_prim_003_delay_element}
C {TR-1um_5_stdcell/OR3.sym} 4540 360 0 0 {name=xgbl_085_or3}
C {TR-1um_5_stdcell/AND2_X1.sym} 5010 360 0 0 {name=xgbl_005_and2_x1}
C {TR-1um_5_stdcell/OR2.sym} 5470 360 0 0 {name=xgbl_042_or2}
C {TR-1um_5_stdcell/AND2_X1.sym} 5910 360 0 0 {name=xgbl_041_and2_x1}
C {TR-1um_5_stdcell/OR2.sym} 6370 360 0 0 {name=xgbl_007_or2}
C {TR-1um_5_stdcell/AND2_X1.sym} 750 670 0 0 {name=xgbl_087_and2_x1}
C {TR-1um_5_stdcell/DFFR.sym} 1200 670 0 0 {name=xgbl_093_dffr}
C {TR-1um_5_stdcell/AND2_X1.sym} 1600 670 0 0 {name=xgbl_044_and2_x1}
C {TR-1um_5_stdcell/NAND2.sym} 2060 670 0 0 {name=xgbl_004_nand2}
C {TR-1um_5_stdcell/AND3_X1.sym} 2540 670 0 0 {name=xgbl_091_and3_x1}
C {TR-1um_5_stdcell/DFFR.sym} 3000 670 0 0 {name=xgbl_113_dffr}
C {TR-1um_5_stdcell/AND3_X1.sym} 3420 670 0 0 {name=xgbl_089_and3_x1}
C {TR-1um_5_stdcell/AND3_X1.sym} 3870 670 0 0 {name=xgbl_082_and3_x1}
C {TR-1um_5_stdcell/AND3_X1.sym} 4330 670 0 0 {name=xgbl_083_and3_x1}
C {TR-1um_5_stdcell/DFFR.sym} 4810 670 0 0 {name=xgbl_111_dffr}
C {TR-1um_5_stdcell/AND3_X1.sym} 5270 670 0 0 {name=xgbl_084_and3_x1}
C {TR-1um_5_stdcell/AND3_X1.sym} 5740 670 0 0 {name=xgbl_009_and3_x1}
C {TR-1um_5_stdcell/AND4_X1.sym} 6180 670 0 0 {name=xgbl_006_and4_x1}
C {TR-1um_5_stdcell/INV_X1.sym} 490 960 0 0 {name=xgbl_036_inv_x1}
C {TR-1um_5_stdcell/MUX2.sym} 940 960 0 0 {name=xgbl_059_mux2}
C {TR-1um_5_stdcell/MUX2.sym} 1360 960 0 0 {name=xgbl_058_mux2}
C {TR-1um_5_stdcell/DFFR.sym} 1800 960 0 0 {name=xgbl_094_dffr}
C {TR-1um_5_stdcell/XOR2.sym} 2250 960 0 0 {name=xgbl_045_xor2}
C {TR-1um_5_stdcell/AND3_X1.sym} 2740 960 0 0 {name=xgbl_057_and3_x1}
C {TR-1um_5_stdcell/AND2_X1.sym} 3180 960 0 0 {name=xgbl_086_and2_x1}
C {TR-1um_5_stdcell/OR3.sym} 3610 960 0 0 {name=xgbl_088_or3}
C {TR-1um_5_stdcell/DFFR.sym} 4070 960 0 0 {name=xgbl_112_dffr}
C {TR-1um_5_stdcell/AND4_X1.sym} 4540 960 0 0 {name=xgbl_001_and4_x1}
C {TR-1um_5_stdcell/NAND3.sym} 5010 960 0 0 {name=xgbl_035_nand3}
C {TR-1um_5_stdcell/AND3_X1.sym} 5470 960 0 0 {name=xgbl_008_and3_x1}
C {TR-1um_5_stdcell/OR2.sym} 5910 960 0 0 {name=xgbl_010_or2}
C {TR-1um_5_stdcell/CLKBUF_X4.sym} 6370 960 0 0 {name=xgbl_prim_005_clock_buffer}
C {TR-1um_5_stdcell/DFFR.sym} 750 1220 0 0 {name=xgbl_103_dffr}
C {TR-1um_5_stdcell/DFFR.sym} 1200 1220 0 0 {name=xgbl_102_dffr}
C {TR-1um_5_stdcell/DFFR.sym} 1600 1220 0 0 {name=xgbl_100_dffr}
C {TR-1um_5_stdcell/MUX2.sym} 2060 1220 0 0 {name=xgbl_055_mux2}
C {TR-1um_5_stdcell/AND4_X1.sym} 2540 1220 0 0 {name=xgbl_064_and4_x1}
C {TR-1um_5_stdcell/AND4_X1.sym} 3000 1220 0 0 {name=xgbl_060_and4_x1}
C {TR-1um_5_stdcell/AND4_X1.sym} 3420 1220 0 0 {name=xgbl_037_and4_x1}
C {TR-1um_5_stdcell/MUX2.sym} 3870 1220 0 0 {name=xgbl_018_mux2}
C {TR-1um_5_stdcell/MUX2.sym} 4330 1220 0 0 {name=xgbl_056_mux2}
C {TR-1um_5_stdcell/DFFR.sym} 4810 1220 0 0 {name=xgbl_107_dffr}
C {TR-1um_5_stdcell/MUX2.sym} 5270 1220 0 0 {name=xgbl_067_mux2}
C {TR-1um_5_stdcell/DFFR.sym} 5740 1220 0 0 {name=xgbl_105_dffr}
C {TR-1um_5_stdcell/MUX2.sym} 6180 1220 0 0 {name=xgbl_063_mux2}
C {TR-1um_5_stdcell/DFFR.sym} 490 1520 0 0 {name=xgbl_101_dffr}
C {TR-1um_5_stdcell/DFFR.sym} 940 1520 0 0 {name=xgbl_106_dffr}
C {TR-1um_5_stdcell/MUX2.sym} 1360 1520 0 0 {name=xgbl_066_mux2}
C {TR-1um_5_stdcell/AND4_X1.sym} 1800 1520 0 0 {name=xgbl_038_and4_x1}
C {TR-1um_5_stdcell/AND4_X1.sym} 2250 1520 0 0 {name=xgbl_065_and4_x1}
C {TR-1um_5_stdcell/AND4_X1.sym} 2740 1520 0 0 {name=xgbl_002_and4_x1}
C {TR-1um_5_stdcell/AND4_X1.sym} 3180 1520 0 0 {name=xgbl_061_and4_x1}
C {TR-1um_5_stdcell/NAND3.sym} 3610 1520 0 0 {name=xgbl_024_nand3}
C {TR-1um_5_stdcell/MUX2.sym} 4070 1520 0 0 {name=xgbl_019_mux2}
C {TR-1um_5_stdcell/MUX2.sym} 4540 1520 0 0 {name=xgbl_022_mux2}
C {TR-1um_5_stdcell/AND2_X1.sym} 5010 1520 0 0 {name=xgbl_021_and2_x1}
C {TR-1um_5_stdcell/MUX2.sym} 5470 1520 0 0 {name=xgbl_062_mux2}
C {TR-1um_5_stdcell/MUX2.sym} 5910 1520 0 0 {name=xgbl_020_mux2}
C {TR-1um_5_stdcell/MUX2.sym} 6370 1520 0 0 {name=xgbl_017_mux2}
C {TR-1um_5_stdcell/INV_X4.sym} 750 1800 0 0 {name=xgbl_prim_004_clock_inverter}
C {TR-1um_5_stdcell/OR2.sym} 1200 1800 0 0 {name=xgbl_032_or2}
C {TR-1um_5_stdcell/OR3.sym} 1600 1800 0 0 {name=xgbl_039_or3}
C {TR-1um_5_stdcell/NOR3.sym} 2060 1800 0 0 {name=xgbl_016_nor3}
C {TR-1um_5_stdcell/AND3_X1.sym} 2540 1800 0 0 {name=xgbl_003_and3_x1}
C {TR-1um_5_stdcell/INV_X1.sym} 3000 1800 0 0 {name=xgbl_015_inv_x1}
C {TR-1um_5_stdcell/NOR3.sym} 3420 1800 0 0 {name=xgbl_033_nor3}
C {TR-1um_5_stdcell/AND3_X1.sym} 3870 1800 0 0 {name=xgbl_000_and3_x1}
C {TR-1um_5_stdcell/MUX2.sym} 4330 1800 0 0 {name=xgbl_025_mux2}
C {TR-1um_5_stdcell/NAND2.sym} 4810 1800 0 0 {name=xgbl_023_nand2}
C {TR-1um_5_stdcell/DFFR.sym} 5270 1800 0 0 {name=xgbl_104_dffr}
C {TR-1um_5_stdcell/OR2.sym} 5740 1800 0 0 {name=xgbl_052_or2}
C {TR-1um_5_stdcell/AND2_X1.sym} 6180 1800 0 0 {name=xgbl_051_and2_x1}
C {TR-1um_5_stdcell/DFFR.sym} 490 2100 0 0 {name=xgbl_109_dffr}
C {TR-1um_5_stdcell/AND4_X1.sym} 940 2100 0 0 {name=xgbl_040_and4_x1}
C {TR-1um_5_stdcell/NOR3.sym} 1360 2100 0 0 {name=xgbl_latch_000_reset}
C {TR-1um_5_stdcell/NOR2.sym} 1800 2100 0 0 {name=xgbl_latch_000_set}
C {TR-1um_5_stdcell/AND3_X1.sym} 2250 2100 0 0 {name=xgbl_050_and3_x1}
C {TR-1um_5_stdcell/AND3_X1.sym} 2740 2100 0 0 {name=xgbl_048_and3_x1}
C {TR-1um_5_stdcell/OR2.sym} 3180 2100 0 0 {name=xgbl_034_or2}
C {TR-1um_5_stdcell/DFFR.sym} 3610 2100 0 0 {name=xgbl_099_dffr}
C {TR-1um_5_stdcell/OR3.sym} 4070 2100 0 0 {name=xgbl_049_or3}
C {TR-1um_5_stdcell/AND3_X1.sym} 4540 2100 0 0 {name=xgbl_027_and3_x1}
C {TR-1um_5_stdcell/AND2_X1.sym} 5010 2100 0 0 {name=xgbl_047_and2_x1}
C {TR-1um_5_stdcell/DFFR.sym} 5470 2100 0 0 {name=xgbl_098_dffr}
C {TR-1um_5_stdcell/AND2_X1.sym} 5910 2100 0 0 {name=xgbl_046_and2_x1}
C {TR-1um_5_stdcell/DFFR.sym} 6370 2100 0 0 {name=xgbl_095_dffr}
C {TR-1um_5_stdcell/NOR3.sym} 540 2400 0 0 {name=xgbl_031_nor3}
C {TR-1um_5_stdcell/AND2_X1.sym} 990 2400 0 0 {name=xgbl_076_and2_x1}
C {TR-1um_5_stdcell/DFFR.sym} 1410 2400 0 0 {name=xgbl_096_dffr}
C {TR-1um_5_stdcell/DFFR.sym} 1830 2400 0 0 {name=xgbl_097_dffr}
C {TR-1um_5_stdcell/NAND3.sym} 2300 2400 0 0 {name=xgbl_026_nand3}
C {TR-1um_5_stdcell/AND4_X1.sym} 2790 2400 0 0 {name=xgbl_068_and4_x1}
C {TR-1um_5_stdcell/MUX2.sym} 3230 2400 0 0 {name=xgbl_073_mux2}
C {TR-1um_5_stdcell/AND2_X1.sym} 3660 2400 0 0 {name=xgbl_053_and2_x1}
C {TR-1um_5_stdcell/AND4_X1.sym} 4120 2400 0 0 {name=xgbl_012_and4_x1}
C {TR-1um_5_stdcell/NAND4.sym} 4590 2400 0 0 {name=xgbl_014_nand4}
C {TR-1um_5_stdcell/AND4_X1.sym} 5060 2400 0 0 {name=xgbl_013_and4_x1}
C {TR-1um_5_stdcell/AND2_X1.sym} 5520 2400 0 0 {name=xgbl_028_and2_x1}
C {TR-1um_5_stdcell/OR4.sym} 5960 2400 0 0 {name=xgbl_030_or4}
C {TR-1um_5_stdcell/AND4_X1.sym} 6420 2400 0 0 {name=xgbl_029_and4_x1}
C {TR-1um_5_stdcell/DFFR.sym} 700 2730 0 0 {name=xgbl_110_dffr}
C {TR-1um_5_stdcell/DFFR.sym} 1150 2730 0 0 {name=xgbl_108_dffr}
C {TR-1um_5_stdcell/AND2_X1.sym} 1550 2730 0 0 {name=xgbl_072_and2_x1}
C {TR-1um_5_stdcell/AND2_X1.sym} 2010 2730 0 0 {name=xgbl_081_and2_x1}
C {TR-1um_5_stdcell/OR2.sym} 2490 2730 0 0 {name=xgbl_071_or2}
C {TR-1um_5_stdcell/XOR2.sym} 2950 2730 0 0 {name=xgbl_070_xor2}
C {TR-1um_5_stdcell/OR2.sym} 3370 2730 0 0 {name=xgbl_069_or2}
C {TR-1um_5_stdcell/OR2.sym} 3820 2730 0 0 {name=xgbl_080_or2}
C {TR-1um_5_stdcell/OR2.sym} 4280 2730 0 0 {name=xgbl_075_or2}
C {TR-1um_5_stdcell/XOR2.sym} 4760 2730 0 0 {name=xgbl_074_xor2}
C {TR-1um_5_stdcell/XOR2.sym} 5220 2730 0 0 {name=xgbl_079_xor2}
C {TR-1um_5_stdcell/AND2_X1.sym} 5690 2730 0 0 {name=xgbl_078_and2_x1}
C {TR-1um_5_stdcell/XNOR2.sym} 6130 2730 0 0 {name=xgbl_077_xnor2}
C {devices/ipin.sym} 260 900 0 0 {name=p1 lab=gpio0_in sim_pinnumber=1}
C {devices/ipin.sym} 300 960 0 0 {name=p2 lab=gpio1_in sim_pinnumber=2}
C {devices/ipin.sym} 300 1490 0 0 {name=p3 lab=reset sim_pinnumber=3}
C {devices/ipin.sym} 300 1540 0 0 {name=p4 lab=scl sim_pinnumber=4}
C {devices/ipin.sym} 300 1000 0 0 {name=p5 lab=sda_in sim_pinnumber=5}
C {devices/opin.sym} 6690 1460 0 0 {name=p6 lab=gdata0_n sim_pinnumber=6}
C {devices/opin.sym} 6650 1160 0 0 {name=p7 lab=gdata1_n sim_pinnumber=7}
C {devices/opin.sym} 6650 1520 0 0 {name=p8 lab=gdirp0 sim_pinnumber=8}
C {devices/opin.sym} 6650 1190 0 0 {name=p9 lab=gdirp1 sim_pinnumber=9}
C {devices/opin.sym} 6650 1800 0 0 {name=p10 lab=gpio0_oe sim_pinnumber=10}
C {devices/opin.sym} 6650 1560 0 0 {name=p11 lab=gpio0_out sim_pinnumber=11}
C {devices/opin.sym} 6650 1240 0 0 {name=p12 lab=gpio1_oe sim_pinnumber=12}
C {devices/opin.sym} 6650 1280 0 0 {name=p13 lab=gpio1_out sim_pinnumber=13}
C {devices/opin.sym} 6650 2100 0 0 {name=p14 lab=sda_drive_low sim_pinnumber=14}
C {devices/ipin.sym} 420 300 0 0 {name=p15 lab=VDD sim_pinnumber=15}
C {devices/ipin.sym} 6540 2800 0 0 {name=p16 lab=VSS sim_pinnumber=16}
C {devices/noconn.sym} 3710 2070 0 0 {name=NC1}
C {devices/noconn.sym} 1230 2740 0 0 {name=NC2}
C {devices/noconn.sym} 780 2740 0 0 {name=NC3}
C {devices/noconn.sym} 6470 2110 0 0 {name=NC4}
C {devices/noconn.sym} 1310 1230 0 0 {name=NC5}
C {devices/noconn.sym} 850 1230 0 0 {name=NC6}
